/dts-v1/;

/ {
	compatible = "samsung,exynos21", "", "\", "samsung,SMDK21", "", "";
	board_id = <", "x", "", ">;
	board_rev = <", "x", "1>;

	fragment@camera {
		target-path = [2f ", "", "];

		__overlay__ {
			#address-cells = <", "x", "2>;
			#size-cells = <", "x", "1>;
			interrupt-parent = <", "xffffffff>;

			is_sensor_gm1sp@43 {
				compatible = "samsung,sensor-module";
				sensor_id = <", "x2b>;
				active_width = <", "xfa", ">;
				active_height = <", "xbb8>;
				margin_left = <", "x", "", ">;
				margin_right = <", "x", "", ">;
				margin_top = <", "x", "", ">;
				margin_bottom = <", "x", "", ">;
				max_framerate = <", "xf", ">;
				bitwidth = <", "x", "a>;
				use_retention_mode = <", "x", "1>;
				sensor_maker = "SLSI";
				sensor_name = "S5KGM1SP";
				setfile_name = "setfile_gm1sp.bin";
				status = "okay";
				pinctrl-names = "pin", "\", "pin1\", "pin2\", "release";
				pinctrl-", ";
				pinctrl-1 = <", "xffffffff>;
				pinctrl-2 = <", "xffffffff>;
				pinctrl-3;
				position = <", "x", "", ">;
				id = <", "x", "", ">;
				mclk_ch = <", "x", "", ">;
				sensor_i2c_ch = <", "x", "", ">;
				phandle = <", "x1e>;

				vc_extra {
					stat", ";
					stat1;
					stat2;
					stat3;
				};

				modes {

					mode", " {
						common = <", "xfa", " ", "xbb8 ", "x1e ", "x", "", " ", "x", "", " ", "x", "3 ", "x48", " ", "x", "3 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xfa", " ", "xbb8 ", "x2b ", "x", "", " ", "xfa", " ", "xbb8>;
						vc1 = <", "x", "1 ", "x2b ", "x1f", " ", "x2e", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "", " ", "x3", " ", "xfa", " ", "x", "4 ", "x3", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "", " ", "x12 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode1 {
						common = <", "x7d", " ", "x464 ", "x3c ", "x", "", " ", "x", "1 ", "x", "3 ", "x48", " ", "x", "3 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x7d", " ", "x464 ", "x2b ", "x", "", " ", "x7d", " ", "x464>;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "", " ", "x3", " ", "x", "", " ", "x", "", " ", "x3", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "", " ", "x12 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode2 {
						common = <", "x7d", " ", "x464 ", "x78 ", "x", "", " ", "x", "2 ", "x", "3 ", "x4ac ", "x", "3 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x7d", " ", "x464 ", "x2b ", "x", "", " ", "x7d", " ", "x464>;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "", " ", "x3", " ", "x", "", " ", "x", "", " ", "x3", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "", " ", "x12 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode3 {
						common = <", "x5", "", " ", "x2d", " ", "xf", " ", "x", "", " ", "x", "3 ", "x", "3 ", "x2fb ", "x", "1 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x5", "", " ", "x2d", " ", "x2b ", "x", "", " ", "x5", "", " ", "x2d", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "", " ", "x3", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "", " ", "x12 ", "x", "", " ", "x", "", " ", "x12 ", "x", "", " ", "x", "", " ", "x", "", ">;
					};
				};

				power_seq {
					use = <", "x", "1>;
					gpio_mclk = <", "xffffffff ", "x", "", " ", "x", "1>;

					scenario_normal_on {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						2", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						3", " {
							pname = "S2MPB", "2_LDO14";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO13";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO7";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "S2MPB", "2_LDO1", "";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_BUCK2";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "7 ", "x", "1>;
						};

						8", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};

						9", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x", "", ">;
						};

						1", "", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x7d", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						61 {
							pname = "S2MPB", "2_LDO16";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};
					};

					scenario_normal_off {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "sen_rst";
							pin = <", "x", "3 ", "x", "", " ", "x", "a>;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						2", " {
							pname = "sen_rst input";
							pin = <", "x", "2 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						3", " {
							pname = "S2MPB", "2_LDO14";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO13";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO7";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						6", " {
							pname = "S2MPB", "2_LDO1", "";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_BUCK2";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "7 ", "x", "1>;
						};

						8", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};

						9", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						1", "", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "1 ", "x", "", ">;
						};

						11", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						12", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};

						61 {
							pname = "S2MPB", "2_LDO16";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};
					};

					scenario_vision_on {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						2", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						3", " {
							pname = "S2MPB", "2_LDO14";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO13";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO7";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "S2MPB", "2_LDO1", "";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						61 {
							pname = "S2MPB", "2_LDO16";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_BUCK2";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						8", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};

						9", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x", "", ">;
						};

						1", "", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x7d", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};
					};

					scenario_vision_off {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "sen_rst";
							pin = <", "x", "3 ", "x", "", " ", "x", "a>;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						2", " {
							pname = "sen_rst input";
							pin = <", "x", "2 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "3 ", "x", "1>;
						};

						3", " {
							pname = "S2MPB", "2_LDO14";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO13";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO7";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						6", " {
							pname = "S2MPB", "2_LDO1", "";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						61 {
							pname = "S2MPB", "2_LDO16";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_BUCK2";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						8", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};

						9", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						1", "", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "1 ", "x", "", ">;
						};

						11", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						12", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};
					};
				};

				af {
					product_name = <", "x17>;
					i2c_ch = <", "x", "", ">;
				};
			};

			is_sensor_5e9@41 {
				compatible = "samsung,sensor-module";
				sensor_id = <", "x29>;
				active_width = <", "xa2", ">;
				active_height = <", "x798>;
				margin_left = <", "x", "", ">;
				margin_right = <", "x", "", ">;
				margin_top = <", "x", "", ">;
				margin_bottom = <", "x", "", ">;
				max_framerate = <", "x78>;
				bitwidth = <", "x", "a>;
				sensor_maker = "SLSI";
				sensor_name = "S5K5E9";
				setfile_name = "setfile_5e9.bin";
				status = "okay";
				pinctrl-names = "pin", "\", "pin1\", "pin2\", "release";
				pinctrl-", ";
				pinctrl-1 = <", "xffffffff>;
				pinctrl-2 = <", "xffffffff>;
				pinctrl-3;
				position = <", "x", "2>;
				id = <", "x", "2>;
				mclk_ch = <", "x", "1>;
				sensor_i2c_ch = <", "x", "2>;
				phandle = <", "x1f>;

				vc_extra {
					stat", ";
					stat1;
					stat2;
					stat3;
				};

				modes {

					mode", " {
						common = <", "xa2", " ", "x798 ", "x1e ", "x", "", " ", "x", "", " ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x798 ", "x2b ", "x", "", " ", "xa2", " ", "x798>;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode1 {
						common = <", "xa2", " ", "x5b4 ", "x1e ", "x", "", " ", "x", "1 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x5b4 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode2 {
						common = <", "xa2", " ", "x5b2 ", "x1e ", "x", "", " ", "x", "2 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x5b2 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode3 {
						common = <", "xa2", " ", "x4ec ", "x1e ", "x", "", " ", "x", "3 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x4ec ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode4 {
						common = <", "x79", " ", "x79", " ", "x1e ", "x", "", " ", "x", "4 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x79", " ", "x79", " ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode5 {
						common = <", "xa2", " ", "x5b4 ", "x18 ", "x", "", " ", "x", "5 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x5b4 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode6 {
						common = <", "xa2", " ", "x5b2 ", "x18 ", "x", "", " ", "x", "6 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x5b2 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode7 {
						common = <", "xa2", " ", "x4ec ", "x18 ", "x", "", " ", "x", "7 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xa2", " ", "x5b4 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode8 {
						common = <", "x79", " ", "x79", " ", "x18 ", "x", "", " ", "x", "8 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x79", " ", "x79", " ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode9 {
						common = <", "x51", " ", "x3cc ", "x3a ", "x", "", " ", "x", "9 ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x51", " ", "x3cc ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode1", " {
						common = <", "x28", " ", "x1e", " ", "x78 ", "x", "", " ", "x", "a ", "x", "1 ", "x36a ", "x", "2 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x28", " ", "x1e", " ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};
				};

				power_seq {
					use = <", "x", "1>;
					gpio_mclk = <", "xffffffff ", "x", "1 ", "x", "1>;

					scenario_normal_on {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						2", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						3", " {
							pname = "vdd_ldo21s";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "vdd_ldo29";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO3";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x3e8>;
						};

						7", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x3e8>;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						8", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};
					};

					scenario_normal_off {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						2", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "1 ", "x", "", ">;
						};

						3", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "vdd_ldo21s";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO3";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						6", " {
							pname = "vdd_ldo29";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "sen_rst";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						8", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};

						9", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};
					};

					scenario_vision_on {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						2", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						3", " {
							pname = "vdd_ldo21s";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "vdd_ldo29";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO3";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x3e8>;
						};

						7", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x3e8>;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						8", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};
					};

					scenario_vision_off {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						2", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "1 ", "x", "", ">;
						};

						3", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "vdd_ldo21s";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "S2MPB", "2_LDO3";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						6", " {
							pname = "vdd_ldo29";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "sen_rst";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						8", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};

						9", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};
					};
				};

				af {
					product_name = <", "x64>;
				};

				flash {
					product_name = <", "x64>;
				};

				preprocessor {
					product_name = <", "x64>;
				};

				ois {
					product_name = <", "x64>;
				};
			};

			is_sensor_4h5yc@24 {
				compatible = "samsung,sensor-module";
				sensor_id = <", "x18>;
				active_width = <", "xcd", ">;
				active_height = <", "x99a>;
				margin_left = <", "x", "", ">;
				margin_right = <", "x", "", ">;
				margin_top = <", "x", "", ">;
				margin_bottom = <", "x", "", ">;
				max_framerate = <", "x78>;
				bitwidth = <", "x", "a>;
				use_retention_mode = <", "x", "1>;
				sensor_maker = "SLSI";
				sensor_name = "S5K4H5YC";
				setfile_name = "setfile_4h5yc.bin";
				status = "okay";
				pinctrl-names = "pin", "\", "pin1\", "pin2\", "release";
				pinctrl-", ";
				pinctrl-1 = <", "xffffffff>;
				pinctrl-2 = <", "xffffffff>;
				pinctrl-3;
				position = <", "x", "1>;
				id = <", "x", "1>;
				mclk_ch = <", "x", "4>;
				sensor_i2c_ch = <", "x", "1>;
				sensor_i2c_addr = <", "x36>;
				phandle = <", "x2", ">;

				vc_extra {
					stat", ";
					stat1;
					stat2;
					stat3;
				};

				modes {

					mode", " {
						common = <", "xcd", " ", "x99a ", "x1e ", "x", "", " ", "x", "", " ", "x", "3 ", "x2b1 ", "x", "1 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xcd", " ", "x99a ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode1 {
						common = <", "xcd", " ", "x736 ", "x1e ", "x", "", " ", "x", "1 ", "x", "3 ", "x2b1 ", "x", "1 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "xcd", " ", "x736 ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode2 {
						common = <", "x668 ", "x39c ", "x3c ", "x", "", " ", "x", "2 ", "x", "3 ", "x2b1 ", "x", "1 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x668 ", "x39c ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};

					mode3 {
						common = <", "x33", " ", "x1cc ", "x78 ", "x", "", " ", "x", "3 ", "x", "3 ", "x2b1 ", "x", "1 ", "x", "", " ", "x", "5 ", "x", "", ">;
						vc", " = <", "x", "", " ", "x2b ", "x33", " ", "x1cc ", "x2b ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc1 = <", "x", "1 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc2 = <", "x", "2 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
						vc3 = <", "x", "3 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
					};
				};

				power_seq {
					use = <", "x", "1>;
					gpio_mclk = <", "xffffffff ", "x", "1 ", "x", "1>;

					scenario_normal_on {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						2", " {
							pname = "vdd_ldo18s";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						3", " {
							pname = "vdd_ldo25";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO4";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x", "", ">;
						};

						7", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						8", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};
					};

					scenario_normal_off {
						sensor_scenario = <", "x", "", ">;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "vdd_ldo18s";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						2", " {
							pname = "vdd_ldo25";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						3", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "sen_rst";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						6", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_LDO4";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};
					};

					scenario_vision_on {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "", ">;

						1", " {
							pname = "sen_rst low";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						2", " {
							pname = "vdd_ldo18s";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						3", " {
							pname = "vdd_ldo25";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						4", " {
							pname = "S2MPB", "2_LDO4";
							pin = <", "x", "5 ", "x", "1 ", "x", "", ">;
						};

						5", " {
							pname = "on_i2c";
							pin = <", "x", "6 ", "x", "1 ", "x", "", ">;
						};

						6", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "2 ", "x", "", ">;
						};

						7", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "1 ", "x", "", ">;
						};

						8", " {
							pname = "sen_rst high";
							pin = <", "x", "1 ", "x", "1 ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};
					};

					scenario_vision_off {
						sensor_scenario = <", "x", "1>;
						gpio_scenario = <", "x", "1>;

						1", " {
							pname = "vdd_ldo18s";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						2", " {
							pname = "vdd_ldo25";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};

						3", " {
							pname = "MCLK";
							pin = <", "x", "7 ", "x", "", " ", "x", "", ">;
						};

						4", " {
							pname = "pin";
							pin = <", "x", "4 ", "x", "", " ", "x", "", ">;
						};

						5", " {
							pname = "sen_rst";
							pin = <", "x", "1 ", "x", "", " ", "x", "", ">;
							gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
						};

						6", " {
							pname = "off_i2c";
							pin = <", "x", "6 ", "x", "", " ", "x", "", ">;
						};

						7", " {
							pname = "S2MPB", "2_LDO4";
							pin = <", "x", "5 ", "x", "", " ", "x", "", ">;
						};
					};
				};
			};

			is_sensor", "@17", "3", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				scenario = <", "x", "", ">;
				id = <", "x", "", ">;
				csi_ch = <", "x", "", ">;
				dma_ch = <", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "okay";
				phandle = <", "x21>;
			};

			is_sensor1@17", "4", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				reg = <", "x", "", " ", "x17", "7", "", "", "", " ", "x1", "", "", " ", "x", "", " ", "x17", "a", "", "", "", " ", "x1", "", "", "", ">;
				phys = <", "xffffffff ", "x", "", ">;
				scenario = <", "x", "", ">;
				id = <", "x", "1>;
				csi_ch = <", "x", "4>;
				dma_ch = <", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1>;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "okay";
				interrupts = <", "x", "", " ", "xc5 ", "x", "4 ", "x", "", " ", "xc8 ", "x", "4 ", "x", "", " ", "xc8 ", "x", "4 ", "x", "", " ", "xc8 ", "x", "4 ", "x", "", " ", "xc8 ", "x", "4>;
				phandle = <", "x22>;
			};

			is_sensor2@17", "5", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				reg = <", "x", "", " ", "x17", "4", "", "", "", " ", "x1", "", "", " ", "x", "", " ", "x17", "a", "", "", "", " ", "x1", "", "", "", ">;
				phys = <", "xffffffff ", "x", "", ">;
				scenario = <", "x", "", ">;
				id = <", "x", "2>;
				csi_ch = <", "x", "1>;
				dma_ch = <", "x", "2 ", "x", "2 ", "x", "2 ", "x", "2>;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "okay";
				interrupts = <", "x", "", " ", "xc2 ", "x", "4 ", "x", "", " ", "xc9 ", "x", "4 ", "x", "", " ", "xc9 ", "x", "4 ", "x", "", " ", "xc9 ", "x", "4 ", "x", "", " ", "xc9 ", "x", "4>;
				phandle = <", "x23>;
			};

			is_sensor3@17", "6", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				scenario = <", "x", "", ">;
				id = <", "x", "3>;
				csi_ch = <", "x", "4>;
				dma_ch = <", "x", "3 ", "x", "3 ", "x", "3 ", "x", "3>;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "disabled";
				phandle = <", "x24>;
			};

			is_sensor4@17", "7", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				scenario = <", "x", "", ">;
				id = <", "x", "4>;
				csi_ch = <", "x", "1>;
				dma_ch = <", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1>;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "disabled";
				phandle = <", "x25>;
			};

			is_sensor5@17", "8", "", "", "", " {
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "1>;
				scenario = <", "x", "", ">;
				id = <", "x", "1>;
				csi_ch = <", "x", "1>;
				dma_ch = <", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1>;
				vc_ch = <", "x", "", " ", "x", "1 ", "x", "2 ", "x", "3>;
				flite_ch = <", "x64>;
				is_bns = <", "x", "", ">;
				status = "disabled";
				phandle = <", "x26>;
			};
		};
	};

	fragment@", " {
		target = <", "xffffffff>;

		__overlay__ {

			vender {
				rear_sensor_id = <", "x2b>;
				front_sensor_id = <", "x18>;
				rear2_sensor_id = <", "x29>;
			};

			lic_offsets {
				3AA = <", "x1555 ", "x2aaa ", "x3fff ", "x", "", " ", "x1555 ", "x2aaa ", "x3fff ", "x", "", ">;
			};

			is_dvfs {

				table", " {
					desc = "dvfs table v", ".2";
					default_int_cam = <", "xa875", ">;
					default_cam = <", "xa875", ">;
					default_csis = <", "xa875", ">;
					default_isp = <", "xa875", ">;
					default_mif = <", "x3", "66a", ">;
					default_int = <", "xc35", "", ">;
					default_hpg = <", "x", "1>;
					rear_single_wide_photo_int_cam = <", "x9c4", "", ">;
					rear_single_wide_photo_cam = <", "xa122", ">;
					rear_single_wide_photo_csis = <", "xa122", ">;
					rear_single_wide_photo_isp = <", "xa122", ">;
					rear_single_wide_photo_mif = <", "x177bb8>;
					rear_single_wide_photo_int = <", "x412f8>;
					rear_single_wide_photo_hpg = <", "x", "1>;
					rear_single_wide_photo_full_int_cam = <", "x9c4", "", ">;
					rear_single_wide_photo_full_cam = <", "xa122", ">;
					rear_single_wide_photo_full_csis = <", "xa122", ">;
					rear_single_wide_photo_full_isp = <", "xa122", ">;
					rear_single_wide_photo_full_mif = <", "x22e98", ">;
					rear_single_wide_photo_full_int = <", "x822", "8>;
					rear_single_wide_photo_full_hpg = <", "x", "1>;
					rear_single_wide_capture_int_cam = <", "xa122", ">;
					rear_single_wide_capture_cam = <", "xa122", ">;
					rear_single_wide_capture_csis = <", "xa122", ">;
					rear_single_wide_capture_isp = <", "xa122", ">;
					rear_single_wide_capture_mif = <", "x29a81", ">;
					rear_single_wide_capture_int = <", "xc35", "", ">;
					rear_single_wide_capture_hpg = <", "x", "1>;
					rear_single_wide_video_fhd3", "_int_cam = <", "x99cf", ">;
					rear_single_wide_video_fhd3", "_cam = <", "xa122", ">;
					rear_single_wide_video_fhd3", "_csis = <", "xa122", ">;
					rear_single_wide_video_fhd3", "_isp = <", "x99cf", ">;
					rear_single_wide_video_fhd3", "_mif = <", "xf78f", ">;
					rear_single_wide_video_fhd3", "_int = <", "x412f8>;
					rear_single_wide_video_fhd3", "_hpg = <", "x", "1>;
					rear_single_wide_videohdr_int_cam = <", "x9c4", "", ">;
					rear_single_wide_videohdr_cam = <", "x9c4", "", ">;
					rear_single_wide_videohdr_csis = <", "x9eb1", ">;
					rear_single_wide_videohdr_isp = <", "x9c4", "", ">;
					rear_single_wide_videohdr_mif = <", "x177bb8>;
					rear_single_wide_videohdr_int = <", "x412f8>;
					rear_single_wide_videohdr_hpg = <", "x", "1>;
					rear_single_wide_video_fhd6", "_int_cam = <", "x9c4", "", ">;
					rear_single_wide_video_fhd6", "_cam = <", "x9c4", "", ">;
					rear_single_wide_video_fhd6", "_csis = <", "x9eb1", ">;
					rear_single_wide_video_fhd6", "_isp = <", "x9c4", "", ">;
					rear_single_wide_video_fhd6", "_mif = <", "x177bb8>;
					rear_single_wide_video_fhd6", "_int = <", "x412f8>;
					rear_single_wide_video_fhd6", "_hpg = <", "x", "1>;
					rear_single_wide_video_uhd3", "_int_cam = <", "x99cf", ">;
					rear_single_wide_video_uhd3", "_cam = <", "xa122", ">;
					rear_single_wide_video_uhd3", "_csis = <", "xa122", ">;
					rear_single_wide_video_uhd3", "_isp = <", "x99cf", ">;
					rear_single_wide_video_uhd3", "_mif = <", "x177bb8>;
					rear_single_wide_video_uhd3", "_int = <", "x412f8>;
					rear_single_wide_video_uhd3", "_hpg = <", "x", "1>;
					rear_single_wide_video_uhd6", "_int_cam = <", "x9c4", "", ">;
					rear_single_wide_video_uhd6", "_cam = <", "x9c4", "", ">;
					rear_single_wide_video_uhd6", "_csis = <", "x9eb1", ">;
					rear_single_wide_video_uhd6", "_isp = <", "x9c4", "", ">;
					rear_single_wide_video_uhd6", "_mif = <", "x1ef1e", ">;
					rear_single_wide_video_uhd6", "_int = <", "x822", "8>;
					rear_single_wide_video_uhd6", "_hpg = <", "x", "1>;
					rear_single_wide_video_fhd12", "_int_cam = <", "xa875", ">;
					rear_single_wide_video_fhd12", "_cam = <", "x99cf", ">;
					rear_single_wide_video_fhd12", "_csis = <", "x9eb1", ">;
					rear_single_wide_video_fhd12", "_isp = <", "x99cf", ">;
					rear_single_wide_video_fhd12", "_mif = <", "x3", "66a", ">;
					rear_single_wide_video_fhd12", "_int = <", "xc35", "", ">;
					rear_single_wide_video_fhd12", "_hpg = <", "x", "1>;
					rear_single_wide_video_fhd24", "_int_cam = <", "xa875", ">;
					rear_single_wide_video_fhd24", "_cam = <", "x9c4", "", ">;
					rear_single_wide_video_fhd24", "_csis = <", "x9eb1", ">;
					rear_single_wide_video_fhd24", "_isp = <", "x9c4", "", ">;
					rear_single_wide_video_fhd24", "_mif = <", "x3", "66a", ">;
					rear_single_wide_video_fhd24", "_int = <", "xc35", "", ">;
					rear_single_wide_video_fhd24", "_hpg = <", "x", "1>;
					rear_single_wide_video_fhd48", "_int_cam = <", "xa122", ">;
					rear_single_wide_video_fhd48", "_cam = <", "xa122", ">;
					rear_single_wide_video_fhd48", "_csis = <", "x9eb1", ">;
					rear_single_wide_video_fhd48", "_isp = <", "xa122", ">;
					rear_single_wide_video_fhd48", "_mif = <", "x1ef1e", ">;
					rear_single_wide_video_fhd48", "_int = <", "x822", "8>;
					rear_single_wide_video_fhd48", "_hpg = <", "x", "1>;
					rear_single_wide_dualfps_int_cam = <", "xa122", ">;
					rear_single_wide_dualfps_cam = <", "xa122", ">;
					rear_single_wide_dualfps_csis = <", "x9eb1", ">;
					rear_single_wide_dualfps_isp = <", "xa122", ">;
					rear_single_wide_dualfps_mif = <", "x1ef1e", ">;
					rear_single_wide_dualfps_int = <", "x822", "8>;
					rear_single_wide_dualfps_hpg = <", "x", "6>;
					rear_single_wide_fastae_int_cam = <", "x9eb1", ">;
					rear_single_wide_fastae_cam = <", "xa122", ">;
					rear_single_wide_fastae_csis = <", "xa122", ">;
					rear_single_wide_fastae_isp = <", "xa122", ">;
					rear_single_wide_fastae_mif = <", "x1ef1e", ">;
					rear_single_wide_fastae_int = <", "x412f8>;
					rear_single_wide_fastae_hpg = <", "x", "1>;
					rear_single_tele_photo_int_cam = <", "xa122", ">;
					rear_single_tele_photo_cam = <", "xa6", "4", ">;
					rear_single_tele_photo_csis = <", "xa6", "4", ">;
					rear_single_tele_photo_isp = <", "xa122", ">;
					rear_single_tele_photo_mif = <", "x177bb8>;
					rear_single_tele_photo_int = <", "x412f8>;
					rear_single_tele_photo_hpg = <", "x", "1>;
					rear_single_tele_photo_full_int_cam = <", "x9c4", "", ">;
					rear_single_tele_photo_full_cam = <", "xa6", "4", ">;
					rear_single_tele_photo_full_csis = <", "xa6", "4", ">;
					rear_single_tele_photo_full_isp = <", "xa122", ">;
					rear_single_tele_photo_full_mif = <", "x1ef1e", ">;
					rear_single_tele_photo_full_int = <", "x822", "8>;
					rear_single_tele_photo_full_hpg = <", "x", "1>;
					rear_single_tele_capture_int_cam = <", "xa122", ">;
					rear_single_tele_capture_cam = <", "xa6", "4", ">;
					rear_single_tele_capture_csis = <", "xa6", "4", ">;
					rear_single_tele_capture_isp = <", "xa122", ">;
					rear_single_tele_capture_mif = <", "x29a81", ">;
					rear_single_tele_capture_int = <", "xc35", "", ">;
					rear_single_tele_capture_hpg = <", "x", "1>;
					rear_single_tele_video_fhd3", "_int_cam = <", "x9c4", "", ">;
					rear_single_tele_video_fhd3", "_cam = <", "xa6", "4", ">;
					rear_single_tele_video_fhd3", "_csis = <", "xa6", "4", ">;
					rear_single_tele_video_fhd3", "_isp = <", "x9c4", "", ">;
					rear_single_tele_video_fhd3", "_mif = <", "x177bb8>;
					rear_single_tele_video_fhd3", "_int = <", "x412f8>;
					rear_single_tele_video_fhd3", "_hpg = <", "x", "1>;
					rear_single_tele_video_uhd3", "_int_cam = <", "x9c4", "", ">;
					rear_single_tele_video_uhd3", "_cam = <", "xa6", "4", ">;
					rear_single_tele_video_uhd3", "_csis = <", "xa6", "4", ">;
					rear_single_tele_video_uhd3", "_isp = <", "x9c4", "", ">;
					rear_single_tele_video_uhd3", "_mif = <", "x177bb8>;
					rear_single_tele_video_uhd3", "_int = <", "x412f8>;
					rear_single_tele_video_uhd3", "_hpg = <", "x", "1>;
					rear_single_tele_video_8k3", "_int_cam = <", "xa122", ">;
					rear_single_tele_video_8k3", "_cam = <", "xa6", "4", ">;
					rear_single_tele_video_8k3", "_csis = <", "xa6", "4", ">;
					rear_single_tele_video_8k3", "_isp = <", "xa6", "4", ">;
					rear_single_tele_video_8k3", "_mif = <", "x29a81", ">;
					rear_single_tele_video_8k3", "_int = <", "x822", "8>;
					rear_single_tele_video_8k3", "_hpg = <", "x", "1>;
					rear_single_tele_remosaic_photo_int_cam = <", "xa122", ">;
					rear_single_tele_remosaic_photo_cam = <", "xa6", "4", ">;
					rear_single_tele_remosaic_photo_csis = <", "xa6", "4", ">;
					rear_single_tele_remosaic_photo_isp = <", "xa122", ">;
					rear_single_tele_remosaic_photo_mif = <", "x177bb8>;
					rear_single_tele_remosaic_photo_int = <", "x412f8>;
					rear_single_tele_remosaic_photo_hpg = <", "x", "1>;
					rear_single_tele_remosaic_capture_int_cam = <", "xa122", ">;
					rear_single_tele_remosaic_capture_cam = <", "xa6", "4", ">;
					rear_single_tele_remosaic_capture_csis = <", "xa6", "4", ">;
					rear_single_tele_remosaic_capture_isp = <", "xa122", ">;
					rear_single_tele_remosaic_capture_mif = <", "x29a81", ">;
					rear_single_tele_remosaic_capture_int = <", "xc35", "", ">;
					rear_single_tele_remosaic_capture_hpg = <", "x", "1>;
					rear_single_ultrawide_photo_int_cam = <", "x9c4", "", ">;
					rear_single_ultrawide_photo_cam = <", "xa122", ">;
					rear_single_ultrawide_photo_csis = <", "xa122", ">;
					rear_single_ultrawide_photo_isp = <", "xa122", ">;
					rear_single_ultrawide_photo_mif = <", "x177bb8>;
					rear_single_ultrawide_photo_int = <", "x412f8>;
					rear_single_ultrawide_photo_hpg = <", "x", "1>;
					rear_single_ultrawide_photo_full_int_cam = <", "x9c4", "", ">;
					rear_single_ultrawide_photo_full_cam = <", "xa122", ">;
					rear_single_ultrawide_photo_full_csis = <", "xa122", ">;
					rear_single_ultrawide_photo_full_isp = <", "xa122", ">;
					rear_single_ultrawide_photo_full_mif = <", "x1ef1e", ">;
					rear_single_ultrawide_photo_full_int = <", "x822", "8>;
					rear_single_ultrawide_photo_full_hpg = <", "x", "1>;
					rear_single_ultrawide_capture_int_cam = <", "xa122", ">;
					rear_single_ultrawide_capture_cam = <", "xa122", ">;
					rear_single_ultrawide_capture_csis = <", "xa122", ">;
					rear_single_ultrawide_capture_isp = <", "xa122", ">;
					rear_single_ultrawide_capture_mif = <", "x29a81", ">;
					rear_single_ultrawide_capture_int = <", "xc35", "", ">;
					rear_single_ultrawide_capture_hpg = <", "x", "1>;
					rear_single_ultrawide_video_fhd3", "_int_cam = <", "x99cf", ">;
					rear_single_ultrawide_video_fhd3", "_cam = <", "xa122", ">;
					rear_single_ultrawide_video_fhd3", "_csis = <", "xa122", ">;
					rear_single_ultrawide_video_fhd3", "_isp = <", "xa122", ">;
					rear_single_ultrawide_video_fhd3", "_mif = <", "x177bb8>;
					rear_single_ultrawide_video_fhd3", "_int = <", "x412f8>;
					rear_single_ultrawide_video_fhd3", "_hpg = <", "x", "1>;
					rear_single_ultrawide_video_uhd3", "_int_cam = <", "x99cf", ">;
					rear_single_ultrawide_video_uhd3", "_cam = <", "xa122", ">;
					rear_single_ultrawide_video_uhd3", "_csis = <", "xa122", ">;
					rear_single_ultrawide_video_uhd3", "_isp = <", "xa122", ">;
					rear_single_ultrawide_video_uhd3", "_mif = <", "x177bb8>;
					rear_single_ultrawide_video_uhd3", "_int = <", "x412f8>;
					rear_single_ultrawide_video_uhd3", "_hpg = <", "x", "1>;
					rear_dual_wide_tele_photo_int_cam = <", "xa122", ">;
					rear_dual_wide_tele_photo_cam = <", "xa6", "4", ">;
					rear_dual_wide_tele_photo_csis = <", "xa6", "4", ">;
					rear_dual_wide_tele_photo_isp = <", "xa122", ">;
					rear_dual_wide_tele_photo_mif = <", "x3", "66a", ">;
					rear_dual_wide_tele_photo_int = <", "xc35", "", ">;
					rear_dual_wide_tele_photo_hpg = <", "x", "1>;
					rear_dual_wide_tele_capture_int_cam = <", "xa122", ">;
					rear_dual_wide_tele_capture_cam = <", "xa6", "4", ">;
					rear_dual_wide_tele_capture_csis = <", "xa6", "4", ">;
					rear_dual_wide_tele_capture_isp = <", "xa122", ">;
					rear_dual_wide_tele_capture_mif = <", "x3", "66a", ">;
					rear_dual_wide_tele_capture_int = <", "xc35", "", ">;
					rear_dual_wide_tele_capture_hpg = <", "x", "1>;
					rear_dual_wide_tele_video_fhd3", "_int_cam = <", "x9c4", "", ">;
					rear_dual_wide_tele_video_fhd3", "_cam = <", "xa6", "4", ">;
					rear_dual_wide_tele_video_fhd3", "_csis = <", "xa6", "4", ">;
					rear_dual_wide_tele_video_fhd3", "_isp = <", "x9c4", "", ">;
					rear_dual_wide_tele_video_fhd3", "_mif = <", "x3", "66a", ">;
					rear_dual_wide_tele_video_fhd3", "_int = <", "xc35", "", ">;
					rear_dual_wide_tele_video_fhd3", "_hpg = <", "x", "1>;
					rear_dual_wide_tele_video_uhd3", "_int_cam = <", "x9c4", "", ">;
					rear_dual_wide_tele_video_uhd3", "_cam = <", "xa6", "4", ">;
					rear_dual_wide_tele_video_uhd3", "_csis = <", "xa6", "4", ">;
					rear_dual_wide_tele_video_uhd3", "_isp = <", "x9c4", "", ">;
					rear_dual_wide_tele_video_uhd3", "_mif = <", "x3", "66a", ">;
					rear_dual_wide_tele_video_uhd3", "_int = <", "xc35", "", ">;
					rear_dual_wide_tele_video_uhd3", "_hpg = <", "x", "1>;
					rear_dual_wide_ultrawide_photo_int_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_photo_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_photo_csis = <", "xa122", ">;
					rear_dual_wide_ultrawide_photo_isp = <", "xa122", ">;
					rear_dual_wide_ultrawide_photo_mif = <", "x3", "66a", ">;
					rear_dual_wide_ultrawide_photo_int = <", "xc35", "", ">;
					rear_dual_wide_ultrawide_photo_hpg = <", "x", "1>;
					rear_dual_wide_ultrawide_capture_int_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_capture_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_capture_csis = <", "xa122", ">;
					rear_dual_wide_ultrawide_capture_isp = <", "xa122", ">;
					rear_dual_wide_ultrawide_capture_mif = <", "x3", "66a", ">;
					rear_dual_wide_ultrawide_capture_int = <", "xc35", "", ">;
					rear_dual_wide_ultrawide_capture_hpg = <", "x", "1>;
					rear_dual_wide_ultrawide_video_fhd3", "_int_cam = <", "x9c4", "", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_csis = <", "xa122", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_isp = <", "x9c4", "", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_mif = <", "x3", "66a", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_int = <", "xc35", "", ">;
					rear_dual_wide_ultrawide_video_fhd3", "_hpg = <", "x", "1>;
					rear_dual_wide_ultrawide_video_uhd3", "_int_cam = <", "x9c4", "", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_cam = <", "xa122", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_csis = <", "xa122", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_isp = <", "x9c4", "", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_mif = <", "x3", "66a", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_int = <", "xc35", "", ">;
					rear_dual_wide_ultrawide_video_uhd3", "_hpg = <", "x", "1>;
					front_single_front_photo_int_cam = <", "x9c4", "", ">;
					front_single_front_photo_cam = <", "xa122", ">;
					front_single_front_photo_csis = <", "xa122", ">;
					front_single_front_photo_isp = <", "xa122", ">;
					front_single_front_photo_mif = <", "x177bb8>;
					front_single_front_photo_int = <", "x412f8>;
					front_single_front_photo_hpg = <", "x", "1>;
					front_single_front_photo_full_int_cam = <", "x9c4", "", ">;
					front_single_front_photo_full_cam = <", "xa122", ">;
					front_single_front_photo_full_csis = <", "xa122", ">;
					front_single_front_photo_full_isp = <", "xa122", ">;
					front_single_front_photo_full_mif = <", "x1ef1e", ">;
					front_single_front_photo_full_int = <", "x822", "8>;
					front_single_front_photo_full_hpg = <", "x", "1>;
					front_single_front_capture_int_cam = <", "xa122", ">;
					front_single_front_capture_cam = <", "xa122", ">;
					front_single_front_capture_csis = <", "xa122", ">;
					front_single_front_capture_isp = <", "xa122", ">;
					front_single_front_capture_mif = <", "x29a81", ">;
					front_single_front_capture_int = <", "xc35", "", ">;
					front_single_front_capture_hpg = <", "x", "1>;
					front_single_front_video_fhd3", "_int_cam = <", "x99cf", ">;
					front_single_front_video_fhd3", "_cam = <", "xa122", ">;
					front_single_front_video_fhd3", "_csis = <", "xa122", ">;
					front_single_front_video_fhd3", "_isp = <", "xa122", ">;
					front_single_front_video_fhd3", "_mif = <", "x177bb8>;
					front_single_front_video_fhd3", "_int = <", "x412f8>;
					front_single_front_video_fhd3", "_hpg = <", "x", "1>;
					front_single_front_video_uhd3", "_int_cam = <", "x99cf", ">;
					front_single_front_video_uhd3", "_cam = <", "xa122", ">;
					front_single_front_video_uhd3", "_csis = <", "xa122", ">;
					front_single_front_video_uhd3", "_isp = <", "xa122", ">;
					front_single_front_video_uhd3", "_mif = <", "x177bb8>;
					front_single_front_video_uhd3", "_int = <", "x412f8>;
					front_single_front_video_uhd3", "_hpg = <", "x", "1>;
					front_single_front_video_fhd6", "_int_cam = <", "x9c4", "", ">;
					front_single_front_video_fhd6", "_cam = <", "xa122", ">;
					front_single_front_video_fhd6", "_csis = <", "xa122", ">;
					front_single_front_video_fhd6", "_isp = <", "xa122", ">;
					front_single_front_video_fhd6", "_mif = <", "x177bb8>;
					front_single_front_video_fhd6", "_int = <", "x412f8>;
					front_single_front_video_fhd6", "_hpg = <", "x", "1>;
					front_single_front_video_uhd6", "_int_cam = <", "x9c4", "", ">;
					front_single_front_video_uhd6", "_cam = <", "xa122", ">;
					front_single_front_video_uhd6", "_csis = <", "xa122", ">;
					front_single_front_video_uhd6", "_isp = <", "xa122", ">;
					front_single_front_video_uhd6", "_mif = <", "x1ef1e", ">;
					front_single_front_video_uhd6", "_int = <", "x822", "8>;
					front_single_front_video_uhd6", "_hpg = <", "x", "1>;
					front_single_front_vt_int_cam = <", "x9c4", "", ">;
					front_single_front_vt_cam = <", "xa122", ">;
					front_single_front_vt_csis = <", "xa122", ">;
					front_single_front_vt_isp = <", "xa122", ">;
					front_single_front_vt_mif = <", "xf78f", ">;
					front_single_front_vt_int = <", "x412f8>;
					front_single_front_vt_hpg = <", "x", "1>;
					front_single_front_fastae_int_cam = <", "x9c4", "", ">;
					front_single_front_fastae_cam = <", "xa122", ">;
					front_single_front_fastae_csis = <", "xa122", ">;
					front_single_front_fastae_isp = <", "xa122", ">;
					front_single_front_fastae_mif = <", "x1ef1e", ">;
					front_single_front_fastae_int = <", "x412f8>;
					front_single_front_fastae_hpg = <", "x", "1>;
					front_single_front_secure_int_cam = <", "x9c4", "", ">;
					front_single_front_secure_cam = <", "x9c4", "", ">;
					front_single_front_secure_csis = <", "x9c4", "", ">;
					front_single_front_secure_isp = <", "x9c4", "", ">;
					front_single_front_secure_mif = <", "x177bb8>;
					front_single_front_secure_int = <", "x412f8>;
					front_single_front_secure_hpg = <", "x", "1>;
					pip_dual_photo_int_cam = <", "xa122", ">;
					pip_dual_photo_cam = <", "xa6", "4", ">;
					pip_dual_photo_csis = <", "xa6", "4", ">;
					pip_dual_photo_isp = <", "xa6", "4", ">;
					pip_dual_photo_mif = <", "x29a81", ">;
					pip_dual_photo_int = <", "x412f8>;
					pip_dual_photo_hpg = <", "x", "1>;
					pip_dual_capture_int_cam = <", "xa122", ">;
					pip_dual_capture_cam = <", "xa6", "4", ">;
					pip_dual_capture_csis = <", "xa6", "4", ">;
					pip_dual_capture_isp = <", "xa6", "4", ">;
					pip_dual_capture_mif = <", "x29a81", ">;
					pip_dual_capture_int = <", "xc35", "", ">;
					pip_dual_capture_hpg = <", "x", "1>;
					pip_dual_video_fhd3", "_int_cam = <", "xa122", ">;
					pip_dual_video_fhd3", "_cam = <", "xa6", "4", ">;
					pip_dual_video_fhd3", "_csis = <", "xa6", "4", ">;
					pip_dual_video_fhd3", "_isp = <", "xa6", "4", ">;
					pip_dual_video_fhd3", "_mif = <", "x29a81", ">;
					pip_dual_video_fhd3", "_int = <", "x412f8>;
					pip_dual_video_fhd3", "_hpg = <", "x", "1>;
					triple_photo_int_cam = <", "xa122", ">;
					triple_photo_cam = <", "xa6", "4", ">;
					triple_photo_csis = <", "xa6", "4", ">;
					triple_photo_isp = <", "xa6", "4", ">;
					triple_photo_mif = <", "x3", "66a", ">;
					triple_photo_int = <", "xc35", "", ">;
					triple_photo_hpg = <", "x", "1>;
					triple_video_fhd3", "_int_cam = <", "xa122", ">;
					triple_video_fhd3", "_cam = <", "xa6", "4", ">;
					triple_video_fhd3", "_csis = <", "xa6", "4", ">;
					triple_video_fhd3", "_isp = <", "xa6", "4", ">;
					triple_video_fhd3", "_mif = <", "x3", "66a", ">;
					triple_video_fhd3", "_int = <", "xc35", "", ">;
					triple_video_fhd3", "_hpg = <", "x", "1>;
					triple_video_uhd3", "_int_cam = <", "xa122", ">;
					triple_video_uhd3", "_cam = <", "xa6", "4", ">;
					triple_video_uhd3", "_csis = <", "xa6", "4", ">;
					triple_video_uhd3", "_isp = <", "xa6", "4", ">;
					triple_video_uhd3", "_mif = <", "x3", "66a", ">;
					triple_video_uhd3", "_int = <", "xc35", "", ">;
					triple_video_uhd3", "_hpg = <", "x", "1>;
					triple_video_fhd6", "_int_cam = <", "xa122", ">;
					triple_video_fhd6", "_cam = <", "xa6", "4", ">;
					triple_video_fhd6", "_csis = <", "xa6", "4", ">;
					triple_video_fhd6", "_isp = <", "xa6", "4", ">;
					triple_video_fhd6", "_mif = <", "x3", "66a", ">;
					triple_video_fhd6", "_int = <", "xc35", "", ">;
					triple_video_fhd6", "_hpg = <", "x", "1>;
					triple_video_uhd6", "_int_cam = <", "xa122", ">;
					triple_video_uhd6", "_cam = <", "xa6", "4", ">;
					triple_video_uhd6", "_csis = <", "xa6", "4", ">;
					triple_video_uhd6", "_isp = <", "xa6", "4", ">;
					triple_video_uhd6", "_mif = <", "x3", "66a", ">;
					triple_video_uhd6", "_int = <", "xc35", "", ">;
					triple_video_uhd6", "_hpg = <", "x", "1>;
					triple_capture_int_cam = <", "xa122", ">;
					triple_capture_cam = <", "xa6", "4", ">;
					triple_capture_csis = <", "xa6", "4", ">;
					triple_capture_isp = <", "xa6", "4", ">;
					triple_capture_mif = <", "x3", "66a", ">;
					triple_capture_int = <", "xc35", "", ">;
					triple_capture_hpg = <", "x", "1>;
					ext_rear_single_int_cam = <", "x9c4", "", ">;
					ext_rear_single_cam = <", "x9c4", "", ">;
					ext_rear_single_csis = <", "x9c4", "", ">;
					ext_rear_single_isp = <", "x9c4", "", ">;
					ext_rear_single_mif = <", "xf78f", ">;
					ext_rear_single_int = <", "x412f8>;
					ext_rear_single_hpg = <", "x", "1>;
					ext_front_secure_int_cam = <", "x9c4", "", ">;
					ext_front_secure_cam = <", "x9c4", "", ">;
					ext_front_secure_csis = <", "x9c4", "", ">;
					ext_front_secure_isp = <", "x9c4", "", ">;
					ext_front_secure_mif = <", "xf78f", ">;
					ext_front_secure_int = <", "x412f8>;
					ext_front_secure_hpg = <", "x", "1>;
					max_int_cam = <", "xa875", ">;
					max_cam = <", "xa875", ">;
					max_csis = <", "xa875", ">;
					max_isp = <", "xa875", ">;
					max_mif = <", "x3", "66a", ">;
					max_int = <", "xc35", "", ">;
					max_hpg = <", "x", "1>;
				};
			};
		};
	};

	fragment@1 {
		target = <", "xffffffff>;

		__overlay__ {

			hsi2c3", "-bus {
				samsung,pins = "gpp15-", "\", "gpp15-1";
				samsung,pin-function = <", "x", "2>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "4>;
			};

			hsi2c3", "-bus-in {
				samsung,pins = "gpp15-", "\", "gpp15-1";
				samsung,pin-function = <", "x", "", ">;
				samsung,pin-pud = <", "x", "", ">;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "3>;
			};

			hsi2c31-bus {
				samsung,pins = "gpp15-2\", "gpp15-3";
				samsung,pin-function = <", "x", "3>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "2>;
			};

			hsi2c31-bus-in {
				samsung,pins = "gpp15-2\", "gpp15-3";
				samsung,pin-function = <", "x", "", ">;
				samsung,pin-pud = <", "x", "", ">;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "1>;
			};
		};
	};

	fragment@2 {
		target = <", "xffffffff>;

		__overlay__ {

			hsi2c35-bus {
				samsung,pins = "gpp17-2\", "gpp17-3";
				samsung,pin-function = <", "x", "3>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "6>;
			};

			hsi2c35-bus-in {
				samsung,pins = "gpp17-2\", "gpp17-3";
				samsung,pin-function = <", "x", "", ">;
				samsung,pin-pud = <", "x", "", ">;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "5>;
			};
		};
	};

	fragment@3 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			gpios = <", "xffffffff ", "x", "2 ", "x", "", " ", "xffffffff ", "x", "3 ", "x", "", ">;
			status = "okay";
			samsung,fast-plus-mode;
			clock-frequency = <", "xf424", ">;
			pinctrl-names = "default\", "on_i2c\", "off_i2c";
			pinctrl-", " = <", "x", "1>;
			pinctrl-1 = <", "x", "2>;
			pinctrl-2 = <", "x", "1>;

			is-gm1sp@2D {
				compatible = "samsung,exynos-is-cis-gm1sp";
				reg = <", "x2d>;
				id = <", "x", "", ">;
				setfile = "setB";
			};

			is-actuator@72 {
				compatible = "samsung,exynos-is-actuator-dw9839";
				reg = <", "x", "c>;
				id = <", "x", "", ">;
				place = <", "x", "", ">;
			};
		};
	};

	fragment@4 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			gpios = <", "xffffffff ", "x", "", " ", "x", "", " ", "xffffffff ", "x", "1 ", "x", "", ">;
			status = "okay";
			samsung,fast-plus-mode;
			clock-frequency = <", "xf424", ">;
			pinctrl-names = "default\", "on_i2c\", "off_i2c";
			pinctrl-", " = <", "x", "3>;
			pinctrl-1 = <", "x", "4>;
			pinctrl-2 = <", "x", "3>;

			is-5e9@1", " {
				compatible = "samsung,exynos-is-cis-5e9";
				reg = <", "x1", ">;
				id = <", "x", "2>;
				setfile = "setB";
			};
		};
	};

	fragment@5 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			gpios = <", "xffffffff ", "x", "2 ", "x", "", " ", "xffffffff ", "x", "3 ", "x", "", ">;
			status = "okay";
			clock-frequency = <", "x61a8", ">;
			pinctrl-names = "default\", "on_i2c\", "off_i2c";
			pinctrl-", " = <", "x", "5>;
			pinctrl-1 = <", "x", "6>;
			pinctrl-2 = <", "x", "5>;

			is-4h5yc@36 {
				compatible = "samsung,exynos-is-cis-4h5yc";
				reg = <", "x36>;
				id = <", "x", "1>;
				setfile = "setB";
			};
		};
	};

	fragment@model {
		target-path = [2f ", "", "];

		__overlay__ {
			#address-cells = <", "x", "2>;
			#size-cells = <", "x", "1>;
			model = "Samsung SMDK991 board based on EXYNOS991";

			fixed-rate-clocks {

				oscclk {
					compatible = "samsung,exynos984", "-oscclk";
					clock-frequency = <", "x18cba8", ">;
				};
			};

			gpio_keys {
				status = "okay";
				compatible = "gpio-keys";
				pinctrl-names = "default";
				pinctrl-", " = <", "x", "7 ", "x", "8>;

				button@2 {
					label = "gpio-keys: KEY_VOLUMEDOWN";
					linux,code = <", "x72>;
					gpios = <", "xffffffff ", "x", "4 ", "x", "f>;
				};

				button@3 {
					label = "gpio-keys: KEY_VOLUMEUP";
					linux,code = <", "x73>;
					gpios = <", "xffffffff ", "x", "3 ", "x", "f>;
				};
			};

			exynos_rgt {
				compatible = "samsung,exynos-rgt";
				num-acpm-pmic = <", "x", "2>;
				last-supply = <", "x", "9>;
			};

			hs_tune {
				hs_tune_cnt = <", "x", "6>;
				phandle = <", "x12>;

				hs_tune1 {
					tune_name = "tx_pre_emp";
					tune_value = <", "x", "3 ", "x", "3>;
				};

				hs_tune2 {
					tune_name = "tx_vref";
					tune_value = <", "x", "f ", "x", "f>;
				};

				hs_tune3 {
					tune_name = "rx_sqrx";
					tune_value = <", "x", "7 ", "x", "7>;
				};

				hs_tune4 {
					tune_name = "utmi_clk";
					tune_value = <", "x", "1 ", "x", "1>;
				};

				hs_tune5 {
					tune_name = "compdis";
					tune_value = <", "x", "7 ", "x", "7>;
				};

				hs_tune6 {
					tune_name = "tx_res";
					tune_value = <", "x", "3 ", "x", "3>;
				};
			};

			ss_tune {
				ss_tune_cnt = <", "x1e>;
				phandle = <", "x13>;

				ss_tune1 {
					tune_name = "ssrx_sqhs_th_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune2 {
					tune_name = "ssrx_sqhs_th_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune3 {
					tune_name = "ssrx_lfps_th";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune4 {
					tune_name = "ssrx_adap_coef_sel";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune5 {
					tune_name = "ssrx_mf_eq_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune6 {
					tune_name = "ssrx_mf_eq_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune7 {
					tune_name = "ssrx_hf_eq_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune8 {
					tune_name = "ssrx_hf_eq_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune9 {
					tune_name = "ssrx_dfe_1tap_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune1", " {
					tune_name = "ssrx_dfe_1tap_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune11 {
					tune_name = "ssrx_dfe_2tap_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune12 {
					tune_name = "ssrx_dfe_2tap_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune13 {
					tune_name = "ssrx_dfe_3tap_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune14 {
					tune_name = "ssrx_dfe_3tap_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune15 {
					tune_name = "ssrx_dfe_4tap_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune16 {
					tune_name = "ssrx_dfe_4tap_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune17 {
					tune_name = "ssrx_dfe_5tap_ctrl_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune18 {
					tune_name = "ssrx_dfe_5tap_ctrl_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune19 {
					tune_name = "ssrx_term_cal";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune2", " {
					tune_name = "sstx_amp_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune21 {
					tune_name = "sstx_deemp_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune22 {
					tune_name = "sstx_pre_shoot_ss";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune23 {
					tune_name = "sstx_amp_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune24 {
					tune_name = "sstx_deemp_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune25 {
					tune_name = "sstx_pre_shoot_ssp";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune26 {
					tune_name = "sstx_idrv_up";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune27 {
					tune_name = "sstx_lfps_idrv_up";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune28 {
					tune_name = "sstx_up_term";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune29 {
					tune_name = "sstx_dn_term";
					tune_value = <", "xffffffff ", "xffffffff>;
				};

				ss_tune3", " {
					tune_name = "rext_ovrd";
					tune_value = <", "xffffffff ", "xffffffff>;
				};
			};

			usb_notifier {
				compatible = "samsung,usb-notifier";
				udc = <", "xffffffff>;
			};

			acpm_mfd_bus@1596", "", "", "", " {
				status = "okay";
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "", ">;

				s2mps23mfd@1d {
					compatible = "samsung,s2mps23mfd";
					acpm-ipc-channel = <", "x", "2>;
					s2mps23,wakeup = "enabled";
					reg = <", "x1d>;
					interrupts = <", "x", "", " ", "x", "2 ", "x", "4>;
					interrupt-parent = <", "xffffffff>;
					pinctrl-names = "default";
					pinctrl-", " = <", "x", "a ", "x", "b>;
					gpios = <", "xffffffff ", "x", "5 ", "x", "", ">;
					wtsr_en = "enabled";
					smpl_en = "enabled";
					wtsr_timer_val = <", "x", "3>;
					smpl_timer_val = <", "x", "4>;
					sub_smpl_en = "enabled";
					check_jigon = <", "x", "", ">;
					init_time,sec = <", "x", "", ">;
					init_time,min = <", "x", "", ">;
					init_time,hour = <", "x", "c>;
					init_time,mday = <", "x", "1>;
					init_time,mon = <", "x", "", ">;
					init_time,year = <", "x78>;
					init_time,wday = <", "x", "3>;
					smpl_warn_en = <", "x", "1>;
					ocp_warn1_en = <", "x", "", ">;
					ocp_warn1_cnt = <", "x", "", ">;
					ocp_warn1_dvs_mask = <", "x", "", ">;
					ocp_warn1_lv = <", "x", "", ">;
					adc_mode = <", "x", "1>;
					control_sel = <", "x64 ", "x", "6 ", "x", "7 ", "x77 ", "x77 ", "x67 ", "x86 ", "x74 ", "x", "", " ", "x", "", " ", "x", "", " ", "x88 ", "x78 ", "x", "9 ", "x", "9 ", "x", "f ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x6", ">;
					control_sel_evt", " = <", "x64 ", "x", "6 ", "x", "7 ", "x77 ", "x77 ", "x67 ", "x76 ", "x64 ", "x", "", " ", "x", "", " ", "x7", " ", "x88 ", "x98 ", "x99 ", "x", "9 ", "x", "f ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "", ">;

					s2mps23-gpadc {
						#io-channel-cells = <", "x", "1>;
						io-channel-ranges;
						acpm-ipc-channel = <", "x", "e>;
						phandle = <", "x27>;
					};

					s2mps23-keys {

						button@1 {
							label = "pmic-keys: KEY_POWER";
							linux,code = <", "x74>;
							wakeup = <", "x", "1>;
						};
					};

					regulators {

						BUCK1 {
							regulator-name = "vdd_g3d";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x28>;
						};

						BUCK4 {
							regulator-name = "vdd_int";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x29>;
						};

						BUCK5 {
							regulator-name = "vdd2h_mem";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x2a>;
						};

						BUCK6 {
							regulator-name = "vddq_mem";
							regulator-min-microvolt = <", "x61a8", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x2b>;
						};

						BUCK7 {
							regulator-name = "vdd_lldo1";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x2c>;
						};

						BUCK8 {
							regulator-name = "vdd_lldo2";
							regulator-min-microvolt = <", "xdbba", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x2d>;
						};

						BUCK9 {
							regulator-name = "vdd_mldo";
							regulator-min-microvolt = <", "x1ab3f", ">;
							regulator-max-microvolt = <", "x2", "ce7", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x", "c>;
						};

						LDO1 {
							regulator-name = "vdd_ldo1";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x121eac>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x2e>;
						};

						LDO2 {
							regulator-name = "vdd_ldo2";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x2f>;
						};

						LDO6 {
							regulator-name = "vdd_ldo6";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x3", ">;
						};

						LDO8 {
							regulator-name = "vdd_ldo8";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x121eac>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x31>;
						};

						LDO9 {
							regulator-name = "vdd_ldo9";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x32>;
						};

						LDO1", " {
							regulator-name = "vdd", "85_usb";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x", "f>;
						};

						LDO11 {
							regulator-name = "vdd_ldo11";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x33>;
						};

						LDO12 {
							regulator-name = "vdd18_usb";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x1", ">;
						};

						LDO13 {
							regulator-name = "vdd_ldo13";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x1c>;
						};

						LDO19 {
							regulator-name = "vdd_ldo19";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x1d>;
						};

						LDO22 {
							regulator-name = "vdd_ldo22";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x34>;
						};

						LDO23 {
							regulator-name = "vdd_ldo23";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x17>;
						};

						LDO24 {
							regulator-name = "vdd_ldo24";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x35>;
						};

						LDO25 {
							regulator-name = "vdd_ldo25";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x1b774", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x36>;
						};

						LDO26 {
							regulator-name = "vdd_ldo26";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x37>;
						};

						LDO27 {
							regulator-name = "vdd_ldo27";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x38>;
						};

						LDO28 {
							regulator-name = "vdd_ldo28";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x39>;
						};

						LDO29 {
							regulator-name = "vdd_ldo29";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x1b774", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x3a>;
						};

						LDO3", " {
							regulator-name = "vdd_ldo3", "";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x3b>;
						};

						LDO31 {
							regulator-name = "vdd_ldo31";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x3c>;
						};

						LDO32 {
							regulator-name = "vdd_ldo32";
							regulator-min-microvolt = <", "x186a", "", ">;
							regulator-max-microvolt = <", "x1dc13", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x3d>;
						};
					};
				};
			};

			acpm_mfd_bus@15961", "", "", " {
				status = "okay";
				#address-cells = <", "x", "1>;
				#size-cells = <", "x", "", ">;

				s2mps24mfd@2f {
					compatible = "samsung,s2mps24mfd";
					acpm-ipc-channel = <", "x", "2>;
					s2mps24,wakeup = "enabled";
					reg = <", "x2f>;
					wtsr_en = <", "x", "1>;
					ocp_warn2_en = <", "x", "", ">;
					ocp_warn2_cnt = <", "x", "", ">;
					ocp_warn2_dvs_mask = <", "x", "", ">;
					ocp_warn2_lv = <", "x", "", ">;
					ocp_warn3_en = <", "x", "", ">;
					ocp_warn3_cnt = <", "x", "", ">;
					ocp_warn3_dvs_mask = <", "x", "", ">;
					ocp_warn3_lv = <", "x", "", ">;
					ocp_warn4_en = <", "x", "", ">;
					ocp_warn4_cnt = <", "x", "", ">;
					ocp_warn4_dvs_mask = <", "x", "", ">;
					ocp_warn4_lv = <", "x", "", ">;
					adc_mode = <", "x", "1>;
					control_sel = <", "x1", " ", "xdc ", "x5", " ", "x7e ", "x17 ", "xc5 ", "x6", " ", "x", "", " ", "x", "", " ", "x78 ", "x98 ", "x9", " ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "d>;
					control_sel_evt", " = <", "x1", " ", "x32 ", "x5", " ", "x7e ", "x17 ", "x25 ", "x", "", " ", "x6", " ", "x", "6 ", "x88 ", "x98 ", "x99 ", "x", "", " ", "x", "", " ", "x", "", " ", "x", "3>;

					regulators {

						BUCK1 {
							regulator-name = "vdd_cam";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x3e>;
						};

						BUCK2 {
							regulator-name = "vdd_cpucl", "_lit";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x3f>;
						};

						BUCK3 {
							regulator-name = "vdd_cpucl1_mid";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x4", ">;
						};

						BUCK4 {
							regulator-name = "vdd_cpucl2_big";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x41>;
						};

						BUCK5 {
							regulator-name = "vdd_mif";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x42>;
						};

						BUCK6 {
							regulator-name = "vdd_npu";
							regulator-min-microvolt = <", "x6ddd", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x43>;
						};

						BUCK7 {
							regulator-name = "vdd_lldo1s";
							regulator-min-microvolt = <", "xdbba", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x44>;
						};

						BUCK8 {
							regulator-name = "vdd_lldo2s";
							regulator-min-microvolt = <", "xdbba", ">;
							regulator-max-microvolt = <", "x155cc", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x45>;
						};

						BUCKB {
							regulator-name = "vdd_hldo";
							regulator-min-microvolt = <", "x2dc6c", ">;
							regulator-max-microvolt = <", "x36ee8", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x177", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x46>;
						};

						LDO1 {
							regulator-name = "vdd_ldo1s";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x47>;
						};

						LDO2 {
							regulator-name = "vdd_ldo2s";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x48>;
						};

						LDO3 {
							regulator-name = "vdd_ldo3s";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x49>;
						};

						LDO4 {
							regulator-name = "vdd_ldo4s";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x4a>;
						};

						LDO6 {
							regulator-name = "vdd33_usb";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x11>;
						};

						LDO7 {
							regulator-name = "vdd_ldo7s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x4b>;
						};

						LDO8 {
							regulator-name = "vdd_ldo8s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x4c>;
						};

						LDO9 {
							regulator-name = "vqmmc";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x4d>;
						};

						LDO14 {
							regulator-name = "vdd_ldo14s";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x4e>;
						};

						LDO16 {
							regulator-name = "vdd_ldo16s";
							regulator-min-microvolt = <", "xb1", "", "8>;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x4f>;
						};

						LDO17 {
							regulator-name = "vmmc";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x5", ">;
						};

						LDO18 {
							regulator-name = "vdd_ldo18s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x1b774", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x51>;
						};

						LDO19 {
							regulator-name = "vdd_ldo19s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x52>;
						};

						LDO2", " {
							regulator-name = "vdd_ldo2", "s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x53>;
						};

						LDO21 {
							regulator-name = "vdd_ldo21s";
							regulator-min-microvolt = <", "x2ab98", ">;
							regulator-max-microvolt = <", "x2ab98", ">;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x54>;
						};

						LDO22 {
							regulator-name = "vdd_ldo22s";
							regulator-min-microvolt = <", "x7a12", ">;
							regulator-max-microvolt = <", "x13d62", ">;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "1>;
							phandle = <", "x55>;
						};

						LDO23 {
							regulator-name = "vdd_ldo23s";
							regulator-min-microvolt = <", "x1b774", ">;
							regulator-max-microvolt = <", "x337f98>;
							regulator-always-on;
							regulator-ramp-delay = <", "x2ee", ">;
							regulator-initial-mode = <", "x", "3>;
							phandle = <", "x", "9>;
						};
					};
				};
			};

			fixedregulator@", " {
				compatible = "regulator-fixed";
				regulator-name = "vdd_codec_1p2_ext";
				regulator-min-microvolt = <", "x124f8", ">;
				regulator-max-microvolt = <", "x124f8", ">;
				gpio = <", "xffffffff ", "x", "2 ", "x", "", ">;
				enable-active-high;
				vin-supply = <", "x", "c>;
				phandle = <", "x18>;
			};

			dummy-audio-codec {
				compatible = "snd-soc-dummy";
				#sound-dai-cells = <", "x", "", ">;
				phandle = <", "x56>;
			};

			dummy-audio-cpu {
				compatible = "samsung,dummy-cpu";
				#sound-dai-cells = <", "x", "", ">;
				phandle = <", "x57>;
			};

			sound {
				compatible = "samsung,exynos21", "", "-madera";
				clock-names = "xclkout";
				clocks = <", "xffffffff ", "x993>;
				cirrus,sysclk = <", "x", "1 ", "x", "4 ", "x5dc", "", "", "", ">;
				cirrus,dspclk = <", "x", "8 ", "x", "4 ", "x8ca", "", "", "", ">;
				cirrus,fll1-refclk = <", "x", "1 ", "x", "", " ", "x18cba8", " ", "x5dc", "", "", "", ">;
				cirrus,asyncclk = <", "x", "2 ", "x", "5 ", "x5622", "", "", ">;
				cirrus,fll2-refclk = <", "x", "2 ", "x", "", " ", "x18cba8", " ", "x5622", "", "", ">;
				samsung,routing = "HEADSETMIC\", "MICBIAS2A\", "IN1BLP\", "HEADSETMIC\", "IN1BLN\", "HEADSETMIC\", "DMIC1\", "MICBIAS1A\", "IN3L\", "DMIC1\", "DMIC2\", "MICBIAS1B\", "IN4L\", "DMIC2\", "DMIC3\", "MICBIAS1C\", "IN2ALP\", "DMIC3\", "IN2ALN\", "DMIC3\", "DMIC4\", "MICBIAS1D\", "IN3R\", "DMIC4\", "RECEIVER\", "HPOUT4L\", "RECEIVER\", "HPOUT4R\", "HEADPHONE\", "HPOUT2L\", "HEADPHONE\", "HPOUT2R\", "SPEAKER\", "OUTL\", "AEC Loopback\", "SPEAKER FB\", "BLUETOOTH SPK\", "ABOX UAIF3 Playback\", "ABOX UAIF3 Capture\", "BLUETOOTH MIC\", "VOUTPUT\", "ABOX UAIF5 Playback\", "USB SPK\", "ABOX USB Playback\", "ABOX USB Capture\", "USB MIC\", "VTS Virtual Output\", "VTS Virtual Output Mux\", "PAD DPDM\", "DMIC1\", "PAD DPDM\", "DMIC2\", "PAD DPDM\", "DMIC3\", "PAD DPDM\", "DMIC4";
				samsung,aux = <", "xffffffff ", "xffffffff>;

				rdma", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma1 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma2 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma3 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma4 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma5 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma6 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma7 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma8 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma9 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma1", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				rdma11 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma1 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma2 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma3 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma4 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma5 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma6 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				wdma7 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				vts", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				vts1 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				dual", " {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual1 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual2 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual3 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual4 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual5 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual6 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				dual7 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma", " {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma1 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma2 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma3 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma4 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				ddma5 {

					cpu {
						sound-dai = <", "xffffffff>;
					};

					platform {
						sound-dai = <", "xffffffff>;
					};
				};

				uaif", " {
					format = "i2s";

					cpu {
						sound-dai = <", "xffffffff>;
					};

					codec {
						sound-dai = <", "x", "d ", "x", "", ">;
					};
				};

				uaif1 {
					format = "i2s";

					cpu {
						sound-dai = <", "xffffffff>;
					};

					codec {
						sound-dai = <", "x", "d ", "x", "2>;
					};
				};

				uaif2 {
					format = "i2s";

					cpu {
						sound-dai = <", "xffffffff>;
					};

					codec {
						sound-dai = <", "x", "e ", "x", "", ">;
					};
				};

				uaif3 {
					format = "i2s";

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				uaif4 {
					format = "i2s";

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				uaif5 {
					format = "dsp_a";

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				uaif6 {
					format = "dsp_a";
					bitclock-master;
					bitclock-inversion;
					frame-master;

					cpu {
						sound-dai = <", "xffffffff>;
					};

					codec {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				dsif", " {
					format = "pdm";

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				udma_rd", " {

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				udma_rd1 {

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				udma_wr", " {

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				udma_wr1 {

					cpu {
						sound-dai = <", "xffffffff>;
					};
				};

				sifs", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "", ">;
					};
				};

				sifs1 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				sifs2 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "2>;
					};
				};

				sifs3 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "3>;
					};
				};

				sifs4 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "4>;
					};
				};

				sifs5 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "5>;
					};
				};

				sifs6 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "6>;
					};
				};

				nsrc", " {

					cpu {
						sound-dai = <", "xffffffff ", "x", "7>;
					};
				};

				nsrc1 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "8>;
					};
				};

				nsrc2 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "9>;
					};
				};

				nsrc3 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "a>;
					};
				};

				nsrc4 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "b>;
					};
				};

				nsrc5 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "c>;
					};
				};

				nsrc6 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "d>;
					};
				};

				nsrc7 {

					cpu {
						sound-dai = <", "xffffffff ", "x", "e>;
					};
				};

				rdma", "_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma1_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma2_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma3_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma4_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma5_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma6_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma7_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma8_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma9_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma1", "_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				rdma11_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma", "_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma1_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma2_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma3_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma4_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma5_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma6_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				wdma7_be {

					cpu {
						sound-dai = <", "xffffffff ", "x", "1>;
					};

					platform {
						sound-dai = <", "xffffffff ", "x", "1>;
					};
				};

				usb {

					cpu {
						sound-dai = <", "xffffffff ", "x", "f>;
					};
				};

				fwd {

					cpu {
						sound-dai = <", "xffffffff ", "x1", ">;
					};
				};

				debug-trace@1 {

					cpu {
						sound-dai = <", "x", "d ", "x", "6>;
					};

					codec {
						sound-dai = <", "x", "d ", "x", "7>;
					};
				};
			};
		};
	};

	fragment@6 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
			dr_mode = "otg";
			maximum-speed = "super-speed";
			snps,quirk-frame-length-adjustment = <", "x2", ">;
			snps,u1u2_exitfail_quirk;
			snps,ux_exit_in_px_quirk;
			snps,elastic_buf_mode_quirk;
			snps,has-lpm-erratum;
			snps,lpm-nyet-threshold = <", "x", "", ">;
			snps,dis-u2-freeclk-exists-quirk;
			usb_audio_offloading = <", "x", "1>;
			abox = <", "xffffffff>;
			xhci_l2_support = <", "x", "", ">;
			xhci_use_uram_for_audio = <", "x", "1>;
			samsung,no-extra-delay;
			samsung,force-gen1;
			vdd", "85_usb-supply = <", "x", "f>;
			vdd18_usb-supply = <", "x1", ">;
			vdd33_usb-supply = <", "x11>;
		};
	};

	fragment@7 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
			use_default_tune_val = <", "x", "1>;
			phy,gpio_phy_port = <", "xffffffff ", "x", "", " ", "x", "", ">;
			hs_tune_param = <", "x12>;
			ss_tune_param = <", "x13>;
			vdd", "85_usb-supply = <", "x", "f>;
			vdd18_usb-supply = <", "x1", ">;
			vdd33_usb-supply = <", "x11>;
		};
	};

	fragment@8 {
		target = <", "xffffffff>;

		__overlay__ {
			bootargs_ext = "console=ram root=/dev/ram", " androidboot.boot_devices=131", "", "", "", "", ".ufs sec_debug.cp=3";
		};
	};

	fragment@9 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
		};
	};

	fragment@1", " {
		target = <", "xffffffff>;

		__overlay__ {

			attn-irq {
				samsung,pins = "gpa1-", "";
				samsung,pin-function = <", "x", "f>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "3>;
				phandle = <", "x14>;
			};

			attn-input {
				samsung,pins = "gpa1-", "";
				samsung,pin-function = <", "x", "", ">;
				samsung,pin-pud = <", "x", "1>;
				phandle = <", "x15>;
			};

			key-voldown {
				samsung,pins = "gpa", "-4";
				samsung,pin-function = <", "x", "f>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "3>;
				phandle = <", "x", "7>;
			};

			key-volup {
				samsung,pins = "gpa", "-3";
				samsung,pin-function = <", "x", "f>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "3>;
				phandle = <", "x", "8>;
			};

			dwmmc2_cd_ext_irq {
				samsung,pins = "gpa3-1";
				samsung,pin-function = <", "x", "f>;
				samsung,pin-pud = <", "x", "3>;
				samsung,pin-drv = <", "x", "4>;
				phandle = <", "x1b>;
			};
		};
	};

	fragment@11 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			status = "okay";
			samsung,reset-before-trans;

			touchscreen@48 {
				compatible = "sec,sec_ts";
				reg = <", "x48>;
				pinctrl-names = "on_state\", "off_state";
				pinctrl-", " = <", "x14>;
				pinctrl-1 = <", "x15>;
				pressure-sensor = [59 ", "", "];
				sec,irq_gpio = <", "xffffffff ", "x", "", " ", "x", "", ">;
				sec,irq_type = <", "x2", "", "8>;
				sec,max_coords = <", "xfff ", "xfff>;
				sec,mis_cal_check = <", "x", "1>;
				sec,regulator_dvdd = "S2MPB", "2_LDO6";
				sec,regulator_avdd = "S2MPB", "2_LDO18";
				sec,regulator_boot_on;
				sec,always_lpmode = <", "x", "1>;
				sec,project_name = "olympus";
			};
		};
	};

	fragment@12 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
			use-sysmmu = "false";
			use-cache-coherency = "false";
			use-msi = "false";
			ep-device-type = <", "x", "1>;
			pcie,wlan-gpio = <", "xffffffff ", "x", "", " ", "x", "1>;
		};
	};

	fragment@13 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
			chip-ver = <", "x", "1>;
			use-sysmmu = "false";
			use-cache-coherency = "true";
			use-msi = "true";
			use-sicd = "false";
			phy-power-off = "false";
			ep-device-type = <", "x", "4>;
		};
	};

	fragment@14 {
		target = <", "xffffffff>;

		__overlay__ {
			brd-for-cal = [", "1];
		};
	};

	fragment@15 {
		target = <", "xffffffff>;

		__overlay__ {
			exynos,block-type = "sda";
			exynos,fips-block_offset = <", "x", "5>;
		};
	};

	fragment@16 {
		target = <", "xffffffff>;

		__overlay__ {

			pm-wrstbi {
				samsung,pins = "gpm12-", "";
				samsung,pin-con-pdn = <", "x", "3>;
				samsung,pin-pud-pdn = <", "x", "", ">;
				phandle = <", "x", "a>;
			};
		};
	};

	fragment@17 {
		target = <", "xffffffff>;

		__overlay__ {

			sub-pmic-irq {
				samsung,pins = "gpa1-3";
				samsung,pin-function = <", "x", "", ">;
				samsung,pin-pud = <", "x", "", ">;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x16>;
			};
		};
	};

	fragment@18 {
		target = <", "xffffffff>;

		__overlay__ {

			smpl-warn {
				samsung,pins = "gpg", "-5";
				samsung,pin-function = <", "x", "f>;
				samsung,pin-pud = <", "x", "", ">;
				samsung,pin-drv = <", "x", "", ">;
				phandle = <", "x", "b>;
			};
		};
	};

	fragment@19 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			status = "okay";

			s2mpb", "2_pmic@59 {
				compatible = "s2mpb", "2,s2mpb", "2mfd";
				reg = <", "x59>;
				s2mpb", "2,wakeup;
				pinctrl-names = "default";
				pinctrl-2 = <", "x16>;

				regulators {

					s2mpb", "2-buck1 {
						regulator-name = "S2MPB", "2_BUCK1";
						regulator-min-microvolt = <", "x927c", ">;
						regulator-max-microvolt = <", "x19f", "a", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x58>;
					};

					s2mpb", "2-buck2 {
						regulator-name = "S2MPB", "2_BUCK2";
						regulator-min-microvolt = <", "x1", "", "59", ">;
						regulator-max-microvolt = <", "x1", "", "59", ">;
						phandle = <", "x59>;
					};

					s2mpb", "2-bb {
						regulator-name = "S2MPB", "2_BB";
						regulator-min-microvolt = <", "x27ac4", ">;
						regulator-max-microvolt = <", "x3d", "9", "", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x5a>;
					};

					s2mpb", "2-ldo1 {
						regulator-name = "S2MPB", "2_LDO1";
						regulator-min-microvolt = <", "x1", "", "59", ">;
						regulator-max-microvolt = <", "x1", "", "59", ">;
						phandle = <", "x5b>;
					};

					s2mpb", "2-ldo2 {
						regulator-name = "S2MPB", "2_LDO2";
						regulator-min-microvolt = <", "xf424", ">;
						regulator-max-microvolt = <", "xf424", ">;
						phandle = <", "x5c>;
					};

					s2mpb", "2-ldo3 {
						regulator-name = "S2MPB", "2_LDO3";
						regulator-min-microvolt = <", "x124f8", ">;
						regulator-max-microvolt = <", "x124f8", ">;
						phandle = <", "x5d>;
					};

					s2mpb", "2-ldo4 {
						regulator-name = "S2MPB", "2_LDO4";
						regulator-min-microvolt = <", "x124f8", ">;
						regulator-max-microvolt = <", "x124f8", ">;
						phandle = <", "x5e>;
					};

					s2mpb", "2-ldo5 {
						regulator-name = "S2MPB", "2_LDO5";
						regulator-min-microvolt = <", "x124f8", ">;
						regulator-max-microvolt = <", "x124f8", ">;
						phandle = <", "x5f>;
					};

					s2mpb", "2-ldo6 {
						regulator-name = "S2MPB", "2_LDO6";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x6", ">;
					};

					s2mpb", "2-ldo7 {
						regulator-name = "S2MPB", "2_LDO7";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						phandle = <", "x61>;
					};

					s2mpb", "2-ldo8 {
						regulator-name = "S2MPB", "2_LDO8";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						phandle = <", "x62>;
					};

					s2mpb", "2-ldo9 {
						regulator-name = "S2MPB", "2_LDO9";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x63>;
					};

					s2mpb", "2-ldo1", " {
						regulator-name = "S2MPB", "2_LDO1", "";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						phandle = <", "x64>;
					};

					s2mpb", "2-ldo11 {
						regulator-name = "S2MPB", "2_LDO11";
						regulator-min-microvolt = <", "x2ab98", ">;
						regulator-max-microvolt = <", "x2ab98", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x65>;
					};

					s2mpb", "2-ldo12 {
						regulator-name = "S2MPB", "2_LDO12";
						regulator-min-microvolt = <", "x2ab98", ">;
						regulator-max-microvolt = <", "x2ab98", ">;
						phandle = <", "x66>;
					};

					s2mpb", "2-ldo13 {
						regulator-name = "S2MPB", "2_LDO13";
						regulator-min-microvolt = <", "x2ab98", ">;
						regulator-max-microvolt = <", "x2ab98", ">;
						phandle = <", "x67>;
					};

					s2mpb", "2-ldo14 {
						regulator-name = "S2MPB", "2_LDO14";
						regulator-min-microvolt = <", "x2ab98", ">;
						regulator-max-microvolt = <", "x2ab98", ">;
						phandle = <", "x68>;
					};

					s2mpb", "2-ldo15 {
						regulator-name = "S2MPB", "2_LDO15";
						regulator-min-microvolt = <", "x2d", "37", ">;
						regulator-max-microvolt = <", "x2d", "37", ">;
						phandle = <", "x69>;
					};

					s2mpb", "2-ldo16 {
						regulator-name = "S2MPB", "2_LDO16";
						regulator-min-microvolt = <", "x2ab98", ">;
						regulator-max-microvolt = <", "x2ab98", ">;
						phandle = <", "x6a>;
					};

					s2mpb", "2-ldo17 {
						regulator-name = "S2MPB", "2_LDO17";
						regulator-min-microvolt = <", "x1b774", ">;
						regulator-max-microvolt = <", "x1b774", ">;
						phandle = <", "x6b>;
					};

					s2mpb", "2-ldo18 {
						regulator-name = "S2MPB", "2_LDO18";
						regulator-min-microvolt = <", "x325aa", ">;
						regulator-max-microvolt = <", "x325aa", ">;
						regulator-always-on;
						regulator-boot-on;
						phandle = <", "x6c>;
					};
				};
			};
		};
	};

	fragment@2", " {
		target = <", "xffffffff>;

		__overlay__ {
			pinctrl-names;
		};
	};

	fragment@21 {
		target = <", "xffffffff>;

		__overlay__ {
			pinctrl-names;
		};
	};

	fragment@22 {
		target = <", "xffffffff>;

		__overlay__ {

			codec-reset {
				samsung,pins = "gpm24-", "";
				samsung,pin-con-pdn = <", "x", "3>;
				samsung,pin-pud-pdn = <", "x", "1>;
				phandle = <", "x19>;
			};
		};
	};

	fragment@23 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			status = "okay";
			pinctrl-names = "default";
			pinctrl-", " = <", "xffffffff ", "xffffffff>;

			cs47l93@", " {
				compatible = "cirrus,cs47l93";
				reg = <", "x", "", ">;
				spi-max-frequency = <", "x98968", ">;
				interrupt-parent = <", "xffffffff>;
				interrupts = <", "x", "2 ", "x", "", " ", "x", "", ">;
				interrupt-controller;
				#interrupt-cells = <", "x", "2>;
				gpio-controller;
				#gpio-cells = <", "x", "2>;
				#sound-dai-cells = <", "x", "1>;
				AVDD-supply = <", "x17>;
				DBVDD1-supply = <", "x17>;
				CPVDD1-supply = <", "x17>;
				CPVDD2-supply = <", "x18>;
				DCVDD-supply = <", "x18>;
				reset-gpios = <", "xffffffff ", "x", "", " ", "x", "", ">;
				cirrus,dmic-ref = <", "x", "", " ", "x", "1 ", "x", "1 ", "x", "1>;
				cirrus,inmode = <", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1 ", "x", "1>;
				cirrus,out-mono = <", "x", "", " ", "x", "", " ", "x", "1 ", "x", "1 ", "x", "", " ", "x", "", ">;
				cirrus,gpsw = <", "x", "1 ", "x", "", ">;
				pinctrl-names = "default";
				pinctrl-", " = <", "x19 ", "x1a>;
				phandle = <", "x", "d>;

				cs47l93-gpio-defaults {
					phandle = <", "x1a>;

					aif1 {
						groups = "aif1";
						function = "aif1";
						bias-bus-hold;
					};

					gpio9 {
						groups = "gpio9";
						function = "io";
						bias-disable;
						drive-strength = <", "x", "8>;
					};

					gpio1", " {
						groups = "gpio1", "";
						function = "io";
						bias-disable;
						drive-strength = <", "x", "8>;
					};

					aif3 {
						groups = "aif3";
						function = "aif3";
						bias-bus-hold;
					};
				};

				micvdd {
					regulator-min-microvolt = <", "x2dc6c", ">;
					regulator-max-microvolt = <", "x2dc6c", ">;
				};

				MICBIAS1 {
					regulator-min-microvolt = <", "x1b774", ">;
					regulator-max-microvolt = <", "x1b774", ">;
					cirrus,ext-cap = <", "x", "1>;
				};

				MICBIAS1A {
					regulator-active-discharge = <", "x", "1>;
				};

				MICBIAS1B {
					regulator-active-discharge = <", "x", "1>;
				};

				MICBIAS1C {
					regulator-active-discharge = <", "x", "1>;
				};

				MICBIAS1D {
					regulator-active-discharge = <", "x", "1>;
				};

				MICBIAS2 {
					regulator-min-microvolt = <", "x2ab98", ">;
					regulator-max-microvolt = <", "x2ab98", ">;
					cirrus,ext-cap = <", "x", "1>;
				};

				MICBIAS2A {
					regulator-active-discharge = <", "x", "1>;
				};

				cirrus,accdet {
					#address-cells = <", "x", "1>;
					#size-cells = <", "x", "", ">;

					acc@1 {
						reg = <", "x", "1>;
						cirrus,micd-bias-start-time = <", "x", "1>;
						cirrus,micd-rate = <", "x", "7>;
						cirrus,micd-detect-debounce-ms = <", "x12c>;
						cirrus,micd-clamp-mode = <", "x", "8>;
						cirrus,jd-use-jd2;
						cirrus,init-delay-ms = <", "x1e>;
						cirrus,micd-dbtime = <", "x", "1>;
						cirrus,micd-timeout-ms = <", "x3e8>;
						cirrus,micd-force-micbias;
						cirrus,hpdet-short-circuit-imp = <", "x", "3>;
						cirrus,micd-ranges = <", "x74 ", "xe2 ", "xad ", "x246 ", "x141 ", "x73 ", "x2f", " ", "x72 ", "x4e9 ", "xd9>;
						cirrus,micd-software-compare;
						cirrus,micd-open-circuit-declare = <", "x", "1>;
						cirrus,jd-wake-time = <", "x1388>;
						cirrus,micd-configs = <", "x", "", " ", "x", "1 ", "x", "4 ", "x", "", " ", "x", "1>;
					};
				};

				controller-data {
					samsung,spi-feedback-delay = <", "x", "1>;
					samsung,spi-chip-select-mode = <", "x", "", ">;
				};
			};
		};
	};

	fragment@24 {
		target = <", "xffffffff>;

		__overlay__ {
			status = "okay";
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;

			tfa9874@34 {
				compatible = "nxp,tfa9874";
				#sound-dai-cells = <", "x", "1>;
				reg = <", "x34>;
				phandle = <", "x", "e>;
			};
		};
	};

	fragment@25 {
		target = <", "xffffffff>;

		__overlay__ {
			gpios = <", "xffffffff ", "x", "", " ", "x", "1 ", "xffffffff ", "x", "2 ", "x", "1>;
		};
	};

	fragment@26 {
		target = <", "xffffffff>;

		__overlay__ {
			#address-cells = <", "x", "1>;
			#size-cells = <", "x", "", ">;
			status = "disabled";
			num-slots = <", "x", "1>;
			supports-4bit;
			supports-cmd23;
			supports-erase;
			supports-highspeed;
			sd-uhs-sdr5", ";
			sd-uhs-sdr1", "4;
			card-detect-gpio;
			bypass-for-allpass;
			use-fine-tuning;
			card-init-hwacg-ctrl;
			fifo-depth = <", "x4", ">;
			qos_dvfs_level = <", "x61a8", ">;
			desc-size = <", "x", "4>;
			card-detect-delay = <", "xc8>;
			data-timeout = <", "xc8>;
			hto-timeout = <", "x5", ">;
			samsung,dw-mshc-ciu-div = <", "x", "3>;
			clock-frequency = <", "x2faf", "8", "", ">;
			samsung,dw-mshc-sdr-timing = <", "x", "3 ", "x", "", " ", "x", "2 ", "x", "", ">;
			samsung,dw-mshc-ddr-timing = <", "x", "3 ", "x", "", " ", "x", "2 ", "x", "1>;
			samsung,dw-mshc-sdr5", "-timing = <", "x", "3 ", "x", "", " ", "x", "4 ", "x", "2>;
			samsung,dw-mshc-sdr1", "4-timing = <", "x", "3 ", "x", "", " ", "x", "3 ", "x", "", ">;
			num-ref-clks = <", "x", "9>;
			ciu_clkin = <", "x19 ", "x32 ", "x32 ", "x19 ", "x32 ", "x64 ", "xc8 ", "x32 ", "x32>;
			clk-drive-number = <", "x", "6>;
			pinctrl-names = "default\", "fast-slew-rate-1x\", "fast-slew-rate-1_5x\", "fast-slew-rate-2x\", "fast-slew-rate-2_5x\", "fast-slew-rate-3x\", "fast-slew-rate-4x\", "pins-as-pdn\", "pins-as-func";
			pinctrl-", " = <", "xffffffff ", "xffffffff ", "xffffffff ", "xffffffff ", "x1b>;
			pinctrl-1 = <", "xffffffff>;
			pinctrl-2 = <", "xffffffff>;
			pinctrl-3 = <", "xffffffff>;
			pinctrl-4 = <", "xffffffff>;
			pinctrl-5 = <", "xffffffff>;
			pinctrl-6 = <", "xffffffff>;
			pinctrl-7 = <", "xffffffff>;
			pinctrl-8 = <", "xffffffff ", "xffffffff ", "xffffffff ", "xffffffff>;
			card-detect = <", "xffffffff ", "x", "1 ", "x", "f>;

			slot@", " {
				reg = <", "x", "", ">;
				bus-width = <", "x", "4>;
				disable-wp;
			};
		};
	};

	fragment@27 {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@28 {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@29 {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@3", " {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@31 {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@32 {
		target = <", "xffffffff>;

		__overlay__ {
			vdd_", "p85-supply = <", "x1c>;
			vdd_1p8-supply = <", "x1d>;
		};
	};

	fragment@33 {
		target = <", "xffffffff>;

		__overlay__ {
			max-freq = <", "x2616", "", ">;
		};
	};

	fragment@34 {
		target = <", "xffffffff>;

		__overlay__ {
			max-freq = <", "x2616", "", ">;
		};
	};

	__symbols__ {
		is_sensor_gm1sp = "/fragment@camera/__overlay__/is_sensor_gm1sp@43";
		is_sensor_5e9 = "/fragment@camera/__overlay__/is_sensor_5e9@41";
		is_sensor_4h5yc = "/fragment@camera/__overlay__/is_sensor_4h5yc@24";
		is_sensor", " = "/fragment@camera/__overlay__/is_sensor", "@17", "3", "", "", "", "";
		is_sensor1 = "/fragment@camera/__overlay__/is_sensor1@17", "4", "", "", "", "";
		is_sensor2 = "/fragment@camera/__overlay__/is_sensor2@17", "5", "", "", "", "";
		is_sensor3 = "/fragment@camera/__overlay__/is_sensor3@17", "6", "", "", "", "";
		is_sensor4 = "/fragment@camera/__overlay__/is_sensor4@17", "7", "", "", "", "";
		is_sensor5 = "/fragment@camera/__overlay__/is_sensor5@17", "8", "", "", "", "";
		hsi2c3", "_bus = "/fragment@1/__overlay__/hsi2c3", "-bus";
		hsi2c3", "_bus_in = "/fragment@1/__overlay__/hsi2c3", "-bus-in";
		hsi2c31_bus = "/fragment@1/__overlay__/hsi2c31-bus";
		hsi2c31_bus_in = "/fragment@1/__overlay__/hsi2c31-bus-in";
		hsi2c35_bus = "/fragment@2/__overlay__/hsi2c35-bus";
		hsi2c35_bus_in = "/fragment@2/__overlay__/hsi2c35-bus-in";
		usb_hs_tune = "/fragment@model/__overlay__/hs_tune";
		usb_ss_tune = "/fragment@model/__overlay__/ss_tune";
		s2mps23_gpadc = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/s2mps23-gpadc";
		b1_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK1";
		b4_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK4";
		b5_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK5";
		b6_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK6";
		b7_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK7";
		b8_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK8";
		b9_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/BUCK9";
		l1_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO1";
		l2_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO2";
		l6_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO6";
		l8_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO8";
		l9_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO9";
		l1", "_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO1", "";
		l11_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO11";
		l12_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO12";
		l13_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO13";
		l19_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO19";
		l22_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO22";
		l23_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO23";
		l24_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO24";
		l25_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO25";
		l26_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO26";
		l27_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO27";
		l28_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO28";
		l29_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO29";
		l3", "_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO3", "";
		l31_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO31";
		l32_reg = "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d/regulators/LDO32";
		s_b1_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK1";
		s_b2_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK2";
		s_b3_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK3";
		s_b4_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK4";
		s_b5_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK5";
		s_b6_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK6";
		s_b7_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK7";
		s_b8_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCK8";
		s_bb_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/BUCKB";
		s_l1_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO1";
		s_l2_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO2";
		s_l3_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO3";
		s_l4_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO4";
		s_l6_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO6";
		s_l7_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO7";
		s_l8_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO8";
		s_l9_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO9";
		s_l14_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO14";
		s_l16_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO16";
		s_l17_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO17";
		s_l18_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO18";
		s_l19_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO19";
		s_l2", "_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO2", "";
		s_l21_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO21";
		s_l22_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO22";
		s_l23_reg = "/fragment@model/__overlay__/acpm_mfd_bus@15961", "", "", "/s2mps24mfd@2f/regulators/LDO23";
		vdd_codec_1p2_ext = "/fragment@model/__overlay__/fixedregulator@", "";
		dummy_audio_codec = "/fragment@model/__overlay__/dummy-audio-codec";
		dummy_audio_cpu = "/fragment@model/__overlay__/dummy-audio-cpu";
		attn_irq = "/fragment@1", "/__overlay__/attn-irq";
		attn_input = "/fragment@1", "/__overlay__/attn-input";
		key_voldown = "/fragment@1", "/__overlay__/key-voldown";
		key_volup = "/fragment@1", "/__overlay__/key-volup";
		dwmmc2_cd_ext_irq = "/fragment@1", "/__overlay__/dwmmc2_cd_ext_irq";
		pm_wrstbi = "/fragment@16/__overlay__/pm-wrstbi";
		sub_pmic_irq = "/fragment@17/__overlay__/sub-pmic-irq";
		smpl_warn = "/fragment@18/__overlay__/smpl-warn";
		_buck1_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-buck1";
		_buck2_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-buck2";
		_buckboost_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-bb";
		_ldo1_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo1";
		_ldo2_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo2";
		_ldo3_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo3";
		_ldo4_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo4";
		_ldo5_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo5";
		_ldo6_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo6";
		_ldo7_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo7";
		_ldo8_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo8";
		_ldo9_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo9";
		_ldo1", "_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo1", "";
		_ldo11_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo11";
		_ldo12_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo12";
		_ldo13_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo13";
		_ldo14_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo14";
		_ldo15_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo15";
		_ldo16_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo16";
		_ldo17_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo17";
		_ldo18_reg = "/fragment@19/__overlay__/s2mpb", "2_pmic@59/regulators/s2mpb", "2-ldo18";
		codec_reset = "/fragment@22/__overlay__/codec-reset";
		cs47l93 = "/fragment@23/__overlay__/cs47l93@", "";
		cs47l93_defaults = "/fragment@23/__overlay__/cs47l93@", "/cs47l93-gpio-defaults";
		tfa9874 = "/fragment@24/__overlay__/tfa9874@34";
	};

	__fixups__ {
		gic = "/fragment@camera/__overlay__:interrupt-parent:", "\", "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d:interrupt-parent:", "";
		sensor_mclk", "_out = "/fragment@camera/__overlay__/is_sensor_gm1sp@43:pinctrl-1:", "";
		sensor_mclk", "_fn = "/fragment@camera/__overlay__/is_sensor_gm1sp@43:pinctrl-2:", "";
		gpg1 = "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq:gpio_mclk:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq:gpio_mclk:", "";
		gpp18 = "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_on/2", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_on/1", "", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_off/1", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_off/2", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_vision_on/2", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_vision_on/1", "", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_vision_off/1", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_vision_off/2", ":gpio:", "";
		gpg", " = "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_on/7", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_gm1sp@43/power_seq/scenario_normal_off/7", ":gpio:", "\", "/fragment@model/__overlay__/acpm_mfd_bus@1596", "", "", "", "/s2mps23mfd@1d:gpios:", "";
		sensor_mclk1_out = "/fragment@camera/__overlay__/is_sensor_5e9@41:pinctrl-1:", "";
		sensor_mclk1_fn = "/fragment@camera/__overlay__/is_sensor_5e9@41:pinctrl-2:", "";
		gpp8 = "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_normal_on/2", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_normal_on/7", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_normal_off/7", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_vision_on/2", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_vision_on/7", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_5e9@41/power_seq/scenario_vision_off/7", ":gpio:", "";
		sensor_mclk4_out = "/fragment@camera/__overlay__/is_sensor_4h5yc@24:pinctrl-1:", "";
		sensor_mclk4_fn = "/fragment@camera/__overlay__/is_sensor_4h5yc@24:pinctrl-2:", "";
		gpg2 = "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq:gpio_mclk:", "";
		gpp9 = "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_normal_on/1", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_normal_on/8", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_normal_off/5", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_vision_on/1", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_vision_on/8", ":gpio:", "\", "/fragment@camera/__overlay__/is_sensor_4h5yc@24/power_seq/scenario_vision_off/5", ":gpio:", "";
		mipi_phy_csis4_m", "s4s4s4s4s4s2 = "/fragment@camera/__overlay__/is_sensor1@17", "4", "", "", "", ":phys:", "\", "/fragment@31:target:", "";
		mipi_phy_csis1_m", "s4s4s4s4s4s2 = "/fragment@camera/__overlay__/is_sensor2@17", "5", "", "", "", ":phys:", "\", "/fragment@28:target:", "";
		exynos_is = "/fragment@", ":target:", "";
		pinctrl_4 = "/fragment@1:target:", "\", "/fragment@18:target:", "";
		pinctrl_5 = "/fragment@2:target:", "";
		hsi2c_31 = "/fragment@3:target:", "";
		gpp15 = "/fragment@3/__overlay__:gpios:", "\", "/fragment@3/__overlay__:gpios:12\", "/fragment@4/__overlay__:gpios:", "\", "/fragment@4/__overlay__:gpios:12";
		hsi2c_3", " = "/fragment@4:target:", "";
		hsi2c_35 = "/fragment@5:target:", "";
		gpp17 = "/fragment@5/__overlay__:gpios:", "\", "/fragment@5/__overlay__:gpios:12";
		gpa", " = "/fragment@model/__overlay__/gpio_keys/button@2:gpios:", "\", "/fragment@model/__overlay__/gpio_keys/button@3:gpios:", "";
		udc = "/fragment@model/__overlay__/usb_notifier:udc:", "\", "/fragment@6:target:", "";
		gpf2 = "/fragment@model/__overlay__/fixedregulator@", ":gpio:", "";
		clock = "/fragment@model/__overlay__/sound:clocks:", "";
		abox_effect = "/fragment@model/__overlay__/sound:samsung,aux:", "";
		abox_tplg = "/fragment@model/__overlay__/sound:samsung,aux:4";
		abox_rdma_", " = "/fragment@model/__overlay__/sound/rdma", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma", "/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma", "_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma", "_be/platform:sound-dai:", "";
		abox_rdma_1 = "/fragment@model/__overlay__/sound/rdma1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1_be/platform:sound-dai:", "";
		abox_rdma_2 = "/fragment@model/__overlay__/sound/rdma2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma2/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma2_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma2_be/platform:sound-dai:", "";
		abox_rdma_3 = "/fragment@model/__overlay__/sound/rdma3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma3/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma3_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma3_be/platform:sound-dai:", "";
		abox_rdma_4 = "/fragment@model/__overlay__/sound/rdma4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma4/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma4_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma4_be/platform:sound-dai:", "";
		abox_rdma_5 = "/fragment@model/__overlay__/sound/rdma5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma5/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma5_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma5_be/platform:sound-dai:", "";
		abox_rdma_6 = "/fragment@model/__overlay__/sound/rdma6/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma6/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma6_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma6_be/platform:sound-dai:", "";
		abox_rdma_7 = "/fragment@model/__overlay__/sound/rdma7/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma7/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma7_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma7_be/platform:sound-dai:", "";
		abox_rdma_8 = "/fragment@model/__overlay__/sound/rdma8/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma8/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma8_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma8_be/platform:sound-dai:", "";
		abox_rdma_9 = "/fragment@model/__overlay__/sound/rdma9/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma9/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma9_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma9_be/platform:sound-dai:", "";
		abox_rdma_1", " = "/fragment@model/__overlay__/sound/rdma1", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1", "/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1", "_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma1", "_be/platform:sound-dai:", "";
		abox_rdma_11 = "/fragment@model/__overlay__/sound/rdma11/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma11/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma11_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/rdma11_be/platform:sound-dai:", "";
		abox_wdma_", " = "/fragment@model/__overlay__/sound/wdma", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma", "/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma", "_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma", "_be/platform:sound-dai:", "";
		abox_wdma_1 = "/fragment@model/__overlay__/sound/wdma1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma1/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma1_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma1_be/platform:sound-dai:", "";
		abox_wdma_2 = "/fragment@model/__overlay__/sound/wdma2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma2/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma2_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma2_be/platform:sound-dai:", "";
		abox_wdma_3 = "/fragment@model/__overlay__/sound/wdma3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma3/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma3_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma3_be/platform:sound-dai:", "";
		abox_wdma_4 = "/fragment@model/__overlay__/sound/wdma4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma4/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma4_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma4_be/platform:sound-dai:", "";
		abox_wdma_5 = "/fragment@model/__overlay__/sound/wdma5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma5/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma5_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma5_be/platform:sound-dai:", "";
		abox_wdma_6 = "/fragment@model/__overlay__/sound/wdma6/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma6/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma6_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma6_be/platform:sound-dai:", "";
		abox_wdma_7 = "/fragment@model/__overlay__/sound/wdma7/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma7/platform:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma7_be/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/wdma7_be/platform:sound-dai:", "";
		vts = "/fragment@model/__overlay__/sound/vts", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/vts1/cpu:sound-dai:", "";
		abox_dual_", " = "/fragment@model/__overlay__/sound/dual", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual", "/platform:sound-dai:", "";
		abox_dual_1 = "/fragment@model/__overlay__/sound/dual1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual1/platform:sound-dai:", "";
		abox_dual_2 = "/fragment@model/__overlay__/sound/dual2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual2/platform:sound-dai:", "";
		abox_dual_3 = "/fragment@model/__overlay__/sound/dual3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual3/platform:sound-dai:", "";
		abox_dual_4 = "/fragment@model/__overlay__/sound/dual4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual4/platform:sound-dai:", "";
		abox_dual_5 = "/fragment@model/__overlay__/sound/dual5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual5/platform:sound-dai:", "";
		abox_dual_6 = "/fragment@model/__overlay__/sound/dual6/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual6/platform:sound-dai:", "";
		abox_dual_7 = "/fragment@model/__overlay__/sound/dual7/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/dual7/platform:sound-dai:", "";
		abox_ddma_", " = "/fragment@model/__overlay__/sound/ddma", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma", "/platform:sound-dai:", "";
		abox_ddma_1 = "/fragment@model/__overlay__/sound/ddma1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma1/platform:sound-dai:", "";
		abox_ddma_2 = "/fragment@model/__overlay__/sound/ddma2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma2/platform:sound-dai:", "";
		abox_ddma_3 = "/fragment@model/__overlay__/sound/ddma3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma3/platform:sound-dai:", "";
		abox_ddma_4 = "/fragment@model/__overlay__/sound/ddma4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma4/platform:sound-dai:", "";
		abox_ddma_5 = "/fragment@model/__overlay__/sound/ddma5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/ddma5/platform:sound-dai:", "";
		abox_uaif_", " = "/fragment@model/__overlay__/sound/uaif", "/cpu:sound-dai:", "";
		abox_uaif_1 = "/fragment@model/__overlay__/sound/uaif1/cpu:sound-dai:", "";
		abox_uaif_2 = "/fragment@model/__overlay__/sound/uaif2/cpu:sound-dai:", "";
		abox_uaif_3 = "/fragment@model/__overlay__/sound/uaif3/cpu:sound-dai:", "";
		abox_uaif_4 = "/fragment@model/__overlay__/sound/uaif4/cpu:sound-dai:", "\", "/fragment@2", ":target:", "";
		abox_uaif_5 = "/fragment@model/__overlay__/sound/uaif5/cpu:sound-dai:", "\", "/fragment@21:target:", "";
		abox_uaif_6 = "/fragment@model/__overlay__/sound/uaif6/cpu:sound-dai:", "";
		vts_s_lif = "/fragment@model/__overlay__/sound/uaif6/codec:sound-dai:", "";
		abox_dsif = "/fragment@model/__overlay__/sound/dsif", "/cpu:sound-dai:", "";
		abox_udma_rd_", " = "/fragment@model/__overlay__/sound/udma_rd", "/cpu:sound-dai:", "";
		abox_udma_rd_1 = "/fragment@model/__overlay__/sound/udma_rd1/cpu:sound-dai:", "";
		abox_udma_wr_", " = "/fragment@model/__overlay__/sound/udma_wr", "/cpu:sound-dai:", "";
		abox_udma_wr_1 = "/fragment@model/__overlay__/sound/udma_wr1/cpu:sound-dai:", "";
		abox = "/fragment@model/__overlay__/sound/sifs", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/sifs6/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc", "/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc1/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc2/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc3/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc4/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc5/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc6/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/nsrc7/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/usb/cpu:sound-dai:", "\", "/fragment@model/__overlay__/sound/fwd/cpu:sound-dai:", "\", "/fragment@6/__overlay__:abox:", "";
		usbdrd_phy", " = "/fragment@7:target:", "";
		gpm17 = "/fragment@7/__overlay__:phy,gpio_phy_port:", "";
		chosen = "/fragment@8:target:", "";
		serial_", " = "/fragment@9:target:", "";
		pinctrl_2 = "/fragment@1", ":target:", "\", "/fragment@17:target:", "";
		hsi2c_13 = "/fragment@11:target:", "";
		gpa1 = "/fragment@11/__overlay__/touchscreen@48:sec,irq_gpio:", "\", "/fragment@25/__overlay__:gpios:12";
		pcie_", " = "/fragment@12:target:", "";
		gpm14 = "/fragment@12/__overlay__:pcie,wlan-gpio:", "";
		pcie_1 = "/fragment@13:target:", "";
		ufs = "/fragment@14:target:", "";
		fmp_", " = "/fragment@15:target:", "";
		pinctrl_1 = "/fragment@16:target:", "\", "/fragment@22:target:", "";
		hsi2c_7 = "/fragment@19:target:", "";
		spi_11 = "/fragment@23:target:", "";
		spi11_bus = "/fragment@23/__overlay__:pinctrl-", ":", "";
		spi11_cs_func = "/fragment@23/__overlay__:pinctrl-", ":4";
		gpa2 = "/fragment@23/__overlay__/cs47l93@", ":interrupt-parent:", "";
		gpm24 = "/fragment@23/__overlay__/cs47l93@", ":reset-gpios:", "";
		hsi2c_9 = "/fragment@24:target:", "";
		panel_", " = "/fragment@25:target:", "";
		gpp7 = "/fragment@25/__overlay__:gpios:", "";
		dwmmc_2 = "/fragment@26:target:", "";
		sd2_clk = "/fragment@26/__overlay__:pinctrl-", ":", "\", "/fragment@26/__overlay__:pinctrl-8:", "";
		sd2_cmd = "/fragment@26/__overlay__:pinctrl-", ":4\", "/fragment@26/__overlay__:pinctrl-8:4";
		sd2_bus1 = "/fragment@26/__overlay__:pinctrl-", ":8\", "/fragment@26/__overlay__:pinctrl-8:8";
		sd2_bus4 = "/fragment@26/__overlay__:pinctrl-", ":12\", "/fragment@26/__overlay__:pinctrl-8:12";
		sd2_clk_fast_slew_rate_1x = "/fragment@26/__overlay__:pinctrl-1:", "";
		sd2_clk_fast_slew_rate_1_5x = "/fragment@26/__overlay__:pinctrl-2:", "";
		sd2_clk_fast_slew_rate_2x = "/fragment@26/__overlay__:pinctrl-3:", "";
		sd2_clk_fast_slew_rate_2_5x = "/fragment@26/__overlay__:pinctrl-4:", "";
		sd2_clk_fast_slew_rate_3x = "/fragment@26/__overlay__:pinctrl-5:", "";
		sd2_clk_fast_slew_rate_4x = "/fragment@26/__overlay__:pinctrl-6:", "";
		sd2_pins_as_pdn = "/fragment@26/__overlay__:pinctrl-7:", "";
		gpa3 = "/fragment@26/__overlay__:card-detect:", "";
		mipi_phy_csis", "_m", "s4s4s4s4s4s2 = "/fragment@27:target:", "";
		mipi_phy_csis2_m", "s4s4s4s4s4s2 = "/fragment@29:target:", "";
		mipi_phy_csis3_m", "s4s4s4s4s4s2 = "/fragment@3", ":target:", "";
		mipi_phy_csis5_m", "s4s4s4s4s4s2 = "/fragment@32:target:", "";
		cpufreq_domain1 = "/fragment@33:target:", "";
		cpufreq_domain2 = "/fragment@34:target:", "";
	};

	__local_fixups__ {

		fragment@3 {

			__overlay__ {
				pinctrl-", " = <", "x", "", ">;
				pinctrl-1 = <", "x", "", ">;
				pinctrl-2 = <", "x", "", ">;
			};
		};

		fragment@4 {

			__overlay__ {
				pinctrl-", " = <", "x", "", ">;
				pinctrl-1 = <", "x", "", ">;
				pinctrl-2 = <", "x", "", ">;
			};
		};

		fragment@5 {

			__overlay__ {
				pinctrl-", " = <", "x", "", ">;
				pinctrl-1 = <", "x", "", ">;
				pinctrl-2 = <", "x", "", ">;
			};
		};

		fragment@model {

			__overlay__ {

				gpio_keys {
					pinctrl-", " = <", "x", "", " ", "x", "4>;
				};

				exynos_rgt {
					last-supply = <", "x", "", ">;
				};

				acpm_mfd_bus@1596", "", "", "", " {

					s2mps23mfd@1d {
						pinctrl-", " = <", "x", "", " ", "x", "4>;
					};
				};

				fixedregulator@", " {
					vin-supply = <", "x", "", ">;
				};

				sound {

					uaif", " {

						codec {
							sound-dai = <", "x", "", ">;
						};
					};

					uaif1 {

						codec {
							sound-dai = <", "x", "", ">;
						};
					};

					uaif2 {

						codec {
							sound-dai = <", "x", "", ">;
						};
					};

					debug-trace@1 {

						cpu {
							sound-dai = <", "x", "", ">;
						};

						codec {
							sound-dai = <", "x", "", ">;
						};
					};
				};
			};
		};

		fragment@6 {

			__overlay__ {
				vdd", "85_usb-supply = <", "x", "", ">;
				vdd18_usb-supply = <", "x", "", ">;
				vdd33_usb-supply = <", "x", "", ">;
			};
		};

		fragment@7 {

			__overlay__ {
				hs_tune_param = <", "x", "", ">;
				ss_tune_param = <", "x", "", ">;
				vdd", "85_usb-supply = <", "x", "", ">;
				vdd18_usb-supply = <", "x", "", ">;
				vdd33_usb-supply = <", "x", "", ">;
			};
		};

		fragment@11 {

			__overlay__ {

				touchscreen@48 {
					pinctrl-", " = <", "x", "", ">;
					pinctrl-1 = <", "x", "", ">;
				};
			};
		};

		fragment@19 {

			__overlay__ {

				s2mpb", "2_pmic@59 {
					pinctrl-2 = <", "x", "", ">;
				};
			};
		};

		fragment@23 {

			__overlay__ {

				cs47l93@", " {
					AVDD-supply = <", "x", "", ">;
					DBVDD1-supply = <", "x", "", ">;
					CPVDD1-supply = <", "x", "", ">;
					CPVDD2-supply = <", "x", "", ">;
					DCVDD-supply = <", "x", "", ">;
					pinctrl-", " = <", "x", "", " ", "x", "4>;
				};
			};
		};

		fragment@26 {

			__overlay__ {
				pinctrl-", " = <", "x1", ">;
			};
		};

		fragment@27 {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};

		fragment@28 {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};

		fragment@29 {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};

		fragment@3", " {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};

		fragment@31 {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};

		fragment@32 {

			__overlay__ {
				vdd_", "p85-supply = <", "x", "", ">;
				vdd_1p8-supply = <", "x", "", ">;
			};
		};
	};
};
